***************************************************************************************
*   This model is a pre-release version.                                              *
*   TSMC Manufacture only supports the formally released SPICE models.                *
*   TSMC reserves the rights to make changes/modifications without written            *
*   notice. Using pre-release SPICE model is at user's risk.                          *
***************************************************************************************
*  **********************************************
*  *             TSMC SPICE MODEL               *
*  **********************************************
*
*    PROCESS :  80nm LOGIC SALICIDE (1P9M, 1.05V/1.8V) (CLN80HS)
*    MODEL   :  BSIM4 ( V4.4 )
*    DOC. NO.:
*    VERSION :  V0.1p2
*    DATE    :  Mar. 25th, 2005
*    HSPICE VERSION : H2004.09
*
********************************************************************************
******************************************************************************
*                                                                            *
*       THIS MODEL LIB CONTAINS :                                            *
*                                                                            *
*       1.LIB TT                                                             *
*             SS                                                             *
*             FF                                                             *
*             SF                                                             *
*             FS                                                             *
*   ( 1.05V Standard-Vt devices with different geometric and corner models)  *
*                                                                            *
*       2.LIB TT_hvt                                                         *
*             SS_hvt                                                         *
*             FF_hvt                                                         *
*             SF_hvt                                                         *
*             FS_hvt                                                         *
*   ( 1.05V High-Vt devices with different geometric and corner models)      *
*                                                                            *
*       3.LIB TT_18                                                          *
*             SS_18                                                          *
*             FF_18                                                          *
*             SF_18                                                          *
*             FS_18                                                          *
*   ( 1.8V devices with different geometric and corner models)               *
*                                                                            *
*       4.LIB TT_BIP                                                         *
*             SS_BIP                                                         *
*             FF_BIP                                                         *
*        ( 1.05V P+/NW/PSUB 10x10, 5x5, and 2x2 vertical PNP bipolar )       *
*                                                                            *
*                                                                            *
*       5.LIB TT_DIO                                                         *
*             SS_DIO                                                         *
*             FF_DIO                                                         *
*        ( 1.05V Standard-Vt P+/NW, N+/PW, and NW/PSUB diode )               *
*                                                                            *
*       6.LIB TT_DIO_hvt                                                     *
*             SS_DIO_hvt                                                     *
*             FF_DIO_hvt                                                     *
*        ( 1.05V High-Vt P+/NW, and N+/PW diode )                             *
*                                                                            *
*       7.LIB TT_DIO_18                                                      *
*             SS_DIO_18                                                      *
*             FF_DIO_18                                                      *
*        ( 1.8V P+/NW, and N+/PW diode )                                     *
*                                                                            *
*       8.LIB TT_MOS_CAP_18                                                  *
*             SS_MOS_CAP_18                                                  *
*             FF_MOS_CAP_18                                                  *
*        ( 1.8V IO NMOS in N-Well varactor )                                 *
*                                                                            *
*       9.LIB RES                                                            *
*        ( resistance )                                                      *
*                                                                            *
*                                                                            *
******************************************************************************
*****************************************************************************************
*                                                                                       *
* 1) To use these models directly by programming in this style:                         *
*                                                                                       *
*     .lib 'lib_path/lib_name' model_name                                               *
*                                                                                       *
*    EX: .lib '/home/user/tsmc/LOGIC/cln80hs_lk_v0d1p2.l' TT                                   *
*        for typical 1.05V Standard Vt N,PMOS                                           *
*    note:                                                                              *
*      corner_name                                                                      *
*       TT : typical model for 1.05V standard-Vt devices                                *
*       SS : Slow NMOS Slow PMOS model for 1.05V standard-Vt devices                    *
*       FF : Fast NMOS Fast PMOS model for 1.05V standard-Vt devices                    *
*       SF : Slow NMOS Fast PMOS model for 1.05V standard-Vt devices                    *
*       FS : Fast NMOS Slow PMOS model for 1.05V standard-Vt devices                    *
*      corner_name                                                                      *
*       TT_hvt : typical model for 1.2V High-Vt devices                                 *
*       SS_hvt : Slow NMOS Slow PMOS model for 1.05V high-Vt devices                     *
*       FF_hvt : Fast NMOS Fast PMOS model for 1.05V high-Vt devices                     *
*       SF_hvt : Slow NMOS Fast PMOS model for 1.05V high-Vt devices                     *
*       FS_hvt : Fast NMOS Slow PMOS model for 1.05V high-Vt devices                     *
*      corner_name                                                                      *
*       TT_18 : typical model for 1.8V devices                                          *
*       SS_18 : Slow NMOS Slow PMOS model for 1.8V devices                              *
*       FF_18 : Fast NMOS Fast PMOS model for 1.8V devices                              *
*       SF_18 : Slow NMOS Fast PMOS model for 1.8V devices                              *
*       FS_18 : Fast NMOS Slow PMOS model for 1.8V devices                              *
* 2) DMCG depends on your layout poly spacer to contact center distance.                *
*    The value listed here is TSMC minimum-rule value. You can change it                *
*    according to your layout.                                                          *
*                                                                                       *
*****************************************************************************************
* NOTE:
* 1. If the layouts are 90% shrunk from CLN90, please put "SCALE=0.9" in the netlists for pre-sim.
*    And for the post sim, LPE tools should take care of the 0.9 scaling.
* 2. LPE needs to extact Rg ,poly-to-contact and poly end cap capacitance for the netlists of real layouts.
*
********************************************************************************
*
*
************************    FLAG FOR CONTACT-POLY CAPACITANCE    ******************************
*
* NOTE:
*  1. The default value of ccoflag is 0, which means that the model will exclude contact-to-poly
*     capacitance.  LPE tools should extract this capacitance during post-layout simulation.
*  2. Users could set ccoflag to 1 for pre-layout simulation where contact-to-poly capacitance
*     with maximum contact density is required.
*
***********************************************************************************************
*.LIB CCO_pre_simu
*.param ccoflag=0
*.ENDL CCO_pre_simu

*.LIB CCO_pre_simu_hvt
*.param ccoflag_hvt=0
*.ENDL CCO_pre_simu_hvt

*.LIB CCO_pre_simu_18
*.param ccoflag_18=0
*.ENDL CCO_pre_simu_18

***************************************************************
*                                                             *
*               1.05V STANDARD VT DEVICE LIB                  *
*                                                             *
***************************************************************

******************************     LIBRARY OF TYPICAL CASE     *******************************
.LIB TT
.param
+ccoflag=0
+toxn           = 1.93E-09      dxw            = 0             dxl            = 0
+cjn            = 9.170E-04     cjswn          = 9.000E-11     cjswgn         = 4.000E-10
+cgon           = 2.643E-11     cgln           = 1.338E-10     dvthn          = 0
+dlvthn         = 0             dwvthn         = 0             dpvthn         = 0
+ddlcn          = 8.953E-09     ntoxn          = 1             cfn            = '1.460E-10 + 2.8e-11*ccoflag'
+dlvoffn        = 0             dwvoffn        = 0             deta0n         = 0
+dweta0n        = 0             dlvsatn        = 0             dpvsatn        = 0
+toxp           = 2.13E-09
+cjp            = 9.57E-04      cjswp          = 7.1E-11       cjswgp         = 3.1E-10
+cgop           = 3.489E-12     cglp           = 1.142E-10     dvthp          = 0
+dlvthp         = 0             dwvthp         = 0             dpvthp         = 0
+du0p           = 0             dlu0p          = 0             dlvsatp        = 0
+dpvsatp        = 0             dvoffp         = 0             dlvoffp        = 0
+dpvoffp        = 0             dleta0p        = 0             dweta0p        = 0
+dpeta0p        = 0             dlk2p          = 0             dlkt1p         = 0
+dpkt1p         = 0             dlatp          = 0             dpatp          = 0
+ddlcp          = 6.667E-09     ntoxp          = 1             cfp            = '1.46E-10 + 2.8e-11*ccoflag'
.lib 'models.sp' MOS
.lib 'models.sp' TT_DIO
.ENDL TT

******************************   LIBRARY OF SNSP CORNER CASE   *******************************
.LIB SS
.param
+ccoflag=0
+toxn           = 1.99E-09      dxw            = -7.20E-09     dxl            = 5.00E-09
+cjn            = 9.812E-04     cjswn          = 9.630E-11     cjswgn         = 4.280E-10
+cgon           = 2.458E-11     cgln           = 1.245E-10     dvthn          = 0.038
+dlvthn         = 0.80E-9       dwvthn         = 1.00E-9       dpvthn         = 1.00E-16
+ddlcn          = 8.953E-09     ntoxn          = 0.5           cfn            = '1.358E-10 + 2.8e-11*ccoflag'
+dlvoffn        = 1e-10         dwvoffn        = 1e-10         deta0n         = -0.0
+dweta0n        = 1e-9          dlvsatn        = 0             dpvsatn        = 1.5e-10
+toxp           = 2.19E-09
+cjp            = 1.024E-03     cjswp          = 7.597E-11     cjswgp         = 3.317E-10
+cgop           = 3.245E-12     cglp           = 1.062E-10     dvthp          = -0.04
+dlvthp         = -1.00E-10     dwvthp         = -3.00e-10     dpvthp         = -2.20E-16
+du0p           = 2.5           dlu0p          = 8.5e-8        dlvsatp        = 1.50e-03
+dpvsatp        = 2.00e-10      dvoffp         = 0             dlvoffp        = 4e-10
+dpvoffp        = -1.00E-16     dleta0p        = 5e-10         dweta0p        = -5e-09
+dpeta0p        = 2e-16         dlk2p          = 9E-10         dlkt1p         = -1.5E-09
+dpkt1p         = 0             dlatp          = 4.3e-3        dpatp          = 0
+ddlcp          = 6.667E-09     ntoxp          = 0             cfp            = '1.3578E-10 + 2.8e-11*ccoflag'
.lib 'models.sp' MOS
.lib 'models.sp' SS_DIO
.ENDL SS

******************************   LIBRARY OF FNFP CORNER CASE   *******************************
.LIB FF
.param
+ccoflag=0
+toxn           = 1.87E-09      dxw            = 7.20E-09      dxl            = -5.00E-09
+cjn            = 8.528E-04     cjswn          = 8.370E-11     cjswgn         = 3.720E-10
+cgon           = 2.828E-11     cgln           = 1.432E-10     dvthn          = -0.038
+dlvthn         = -1.20E-09     dwvthn         = -2.00E-10     dpvthn         = -1.20E-16
+ddlcn          = 8.953E-09     ntoxn          = 1.5           cfn            = '1.562E-10 + 2.8e-11*ccoflag'
+dlvoffn        = 0.8e-9        dwvoffn        = -6e-9         deta0n         = 0.08
+dweta0n        = 3.0e-9        dlvsatn        = -2e-4         dpvsatn        = -1.5e-10
+toxp           = 2.07E-09
+cjp            = 8.9E-04       cjswp          = 6.603E-11     cjswgp         = 2.883E-10
+cgop           = 3.733E-12     cglp           = 1.222E-10     dvthp          = 0.035
+dlvthp         = 5.0E-11       dwvthp         = 3.0E-10       dpvthp         = 2.20E-16
+du0p           = 0             dlu0p          = 0             dlvsatp        = -1.65E-03
+dpvsatp        = -5.6E-11      dvoffp         = -0.015        dlvoffp        = -0.0e-9
+dpvoffp        = -1.0E-16      dleta0p        = 7.0E-9        dweta0p        = 6.0E-9
+dpeta0p        = -7.0E-16      dlk2p          = -0.0E-11      dlkt1p         = 1.60E-09
+dpkt1p         = -1.0E-16      dlatp          = -1.6E-03      dpatp          = 1.0E-10
+ddlcp          = 6.667E-09     ntoxp          = 1.7           cfp            = '1.5622E-10 + 2.8e-11*ccoflag'
.lib 'models.sp' MOS
.lib 'models.sp' FF_DIO
.ENDL FF

******************************   LIBRARY OF SNFP CORNER CASE   *******************************
.LIB SF
.param
+ccoflag=0
+toxn           = 1.93E-09      dxw            = 0             dxl            = 0
+cjn            = 9.812E-04     cjswn          = 9.630E-11     cjswgn         = 4.280E-10
+cgon           = 2.643E-11     cgln           = 1.338E-10     dvthn          = 0.032
+dlvthn         = 0.60E-9       dwvthn         = 0.8e-9        dpvthn         = 0.80E-16
+ddlcn          = 8.953E-09     ntoxn          = 1             cfn            = '1.460E-10 + 2.8e-11*ccoflag'
+dlvoffn        = 1e-10         dwvoffn        = 1e-10         deta0n         = -0.00
+dweta0n        = 1e-9          dlvsatn        = 0             dpvsatn        = 1.5e-10
+toxp           = 2.13E-09
+cjp            = 8.9E-04       cjswp          = 6.603E-11     cjswgp         = 2.883E-10
+cgop           = 3.489E-12     cglp           = 1.142E-10     dvthp          = 0.035
+dlvthp         = 4.00E-10      dwvthp         = 5.0E-10       dpvthp         = 2.40E-16
+du0p           = -9E-1         dlu0p          = 0             dlvsatp        = -5.0E-04
+dpvsatp        = -1.2E-11      dvoffp         = -0.015        dlvoffp        = -6.0e-10
+dpvoffp        = -5.0E-16      dleta0p        = 4.0E-9        dweta0p        = 6.0E-9
+dpeta0p        = -5.0E-16      dlk2p          = -1.6E-10      dlkt1p         = 3.00E-09
+dpkt1p         = -1.0E-16      dlatp          = -2.4E-03      dpatp          = 1.0E-10
+ddlcp          = 6.667E-09     ntoxp          = 1             cfp            = '1.46E-10 + 2.8e-11*ccoflag'
.lib 'models.sp' MOS
.ENDL SF

******************************   LIBRARY OF FNSP CORNER CASE   *******************************
.LIB FS
.param
+ccoflag=0
+toxn           = 1.93E-09      dxw            = 0             dxl            = 0
+cjn            = 8.528E-04     cjswn          = 8.370E-11     cjswgn         = 3.720E-10
+cgon           = 2.643E-11     cgln           = 1.338E-10     dvthn          = -0.032
+dlvthn         = -1.20E-09     dwvthn         = -1.80E-10     dpvthn         = -1.00E-16
+ddlcn          = 8.953E-09     ntoxn          = 1             cfn            = '1.460E-10 + 2.8e-11*ccoflag'
+dlvoffn        = 0.8e-9        dwvoffn        = -6e-9         deta0n         = 0.08
+dweta0n        = 3.0e-9        dlvsatn        = -2e-4         dpvsatn        = -1.5e-10
+toxp           = 2.13E-09
+cjp            = 1.024E-03     cjswp          = 7.597E-11     cjswgp         = 3.317E-10
+cgop           = 3.489E-12     cglp           = 1.142E-10     dvthp          = -0.04
+dlvthp         = -4.00E-10     dwvthp         = -3.60e-10     dpvthp         = -2.00E-16
+du0p           = 2.5           dlu0p          = -1E-07        dlvsatp        = 2.00e-04
+dpvsatp        = 3.50e-10      dvoffp         = 0             dlvoffp        = 2.0e-10
+dpvoffp        = -1.10E-16     dleta0p        = -4e-10        dweta0p        = 0
+dpeta0p        = 5e-17         dlk2p          = 9E-10         dlkt1p         = 0
+dpkt1p         = 0             dlatp          = 0             dpatp          = 0
+ddlcp          = 6.667E-09     ntoxp          = 1             cfp            = '1.46E-10 + 2.8e-11*ccoflag'
.lib 'models.sp' MOS
.ENDL FS

*
***************************************************************
*                                                             *
*               1.05V HIGH VT DEVICE LIB                      *
*                                                             *
***************************************************************
******************************    LIBRARY OF TYPICAL CASE    ******************************
.LIB TT_hvt
.param
+ccoflag_hvt=0
+toxn_hvt       = 1.93E-09      dxw_hvt        = 0             dxl_hvt        = 0
+cjn_hvt        = 9.170E-04     cjswn_hvt      = 9.000E-11     cjswgn_hvt     = 4.300E-10
+cgon_hvt       = 2.834E-11     cgln_hvt       = 1.203E-10     dvthn_hvt      = 0
+dlvthn_hvt     = 0             dwvthn_hvt     = 0             dpvthn_hvt     = 0
+ddlcn_hvt      = 8.241E-09     ntoxn_hvt      = 1             cfn_hvt        = '1.460E-10 + 2.8e-11*ccoflag_hvt'
+dlvoffn_hvt    = 0             dwvoffn_hvt    = 0             deta0n_hvt     = 0
+dweta0n_hvt    = 0             dlvsatn_hvt    = 0             dpvsatn_hvt    = 0
+dlatn_hvt      = 0             dpatn_hvt      = 0
+toxp_hvt       = 2.13E-09
+cjp_hvt        = 9.57E-04      cjswp_hvt      = 7.1E-11       cjswgp_hvt     = 3.1E-10
+cgop_hvt       = 6.974E-13     cglp_hvt       = 1.1085E-10    dvthp_hvt      = 0
+dlvthp_hvt     = 0             dwvthp_hvt     = 0             dpvthp_hvt     = 0
+drdswp_hvt     = 0             du0p_hvt       = 0             dpu0p_hvt      = 0
+dlvsatp_hvt    = 0             dpvsatp_hvt    = 0             dppclmp_hvt    = 0
+dpnfactorp_hvt = 0             dvoffp_hvt     = 0             dlvoffp_hvt    = 0
+dpvoffp_hvt    = 0             dleta0p_hvt    = 0             dweta0p_hvt    = 0
+dpa0p_hvt      = 0             dlk2p_hvt      = 0             dlkt1p_hvt     = 0
+dpkt1p_hvt     = 0             dlatp_hvt      = 0             dpatp_hvt      = 0
+ddlcp_hvt      = 6.0611E-09    ntoxp_hvt      = 1             cfp_hvt        = '1.46E-10 + 2.8e-11*ccoflag_hvt'
.lib 'models.sp' MOS_hvt
.lib 'models.sp' TT_DIO_hvt
.ENDL TT_hvt

******************************   LIBRARY OF SNSP CORNER CASE   *******************************
.LIB SS_hvt
.param
+ccoflag_hvt=0
+toxn_hvt       = 1.99E-09      dxw_hvt        = -7.20E-09     dxl_hvt        = 5.00E-09
+cjn_hvt        = 9.812E-04     cjswn_hvt      = 9.630E-11     cjswgn_hvt     = 4.601E-10
+cgon_hvt       = 2.635E-11     cgln_hvt       = 1.119E-10     dvthn_hvt      = 0.036
+dlvthn_hvt     = 0.70E-9       dwvthn_hvt     = 0.90E-9       dpvthn_hvt     = 1.00E-16
+ddlcn_hvt      = 8.241E-09     ntoxn_hvt      = 0.5           cfn_hvt        = '1.358E-10 + 2.8e-11*ccoflag_hvt'
+dlvoffn_hvt    = 1e-10         dwvoffn_hvt    = 1e-10         deta0n_hvt     = -0.0
+dweta0n_hvt    = 1.4e-9        dlvsatn_hvt    = 0             dpvsatn_hvt    = 1.5e-10
+dlatn_hvt      = 5e-4          dpatn_hvt      = 0
+toxp_hvt       = 2.19E-09
+cjp_hvt        = 1.024E-03     cjswp_hvt      = 7.597E-11     cjswgp_hvt     = 3.317E-10
+cgop_hvt       = 6.486E-13     cglp_hvt       = 1.0309E-10    dvthp_hvt      = -0.04
+dlvthp_hvt     = -2.00E-10     dwvthp_hvt     = -3.00e-10     dpvthp_hvt     = -2.20E-16
+drdswp_hvt     = -40           du0p_hvt       = 1.5           dpu0p_hvt      = 0.8e-14
+dlvsatp_hvt    = 2.40E-03      dpvsatp_hvt    = 3e-10         dppclmp_hvt    = 0
+dpnfactorp_hvt = 0             dvoffp_hvt     = 0             dlvoffp_hvt    = -0.5e-9
+dpvoffp_hvt    = -0.6E-16      dleta0p_hvt    = 2e-9          dweta0p_hvt    = 3e-9
+dpa0p_hvt      = 0             dlk2p_hvt      = 9E-10         dlkt1p_hvt     = 0
+dpkt1p_hvt     = 0             dlatp_hvt      = 8.0e-3        dpatp_hvt      = 1.5e-10
+ddlcp_hvt      = 6.0611E-09    ntoxp_hvt      = 0             cfp_hvt        = '1.3578E-10 + 2.8e-11*ccoflag_hvt'
.lib 'models.sp' MOS_hvt
.lib 'models.sp' SS_DIO_hvt
.ENDL SS_hvt

******************************   LIBRARY OF FNFP CORNER CASE   *******************************
.LIB FF_hvt
.param
+ccoflag_hvt=0
+toxn_hvt       = 1.87E-09      dxw_hvt        = 7.20E-09      dxl_hvt        = -5.00E-09
+cjn_hvt        = 8.528E-04     cjswn_hvt      = 8.370E-11     cjswgn_hvt     = 3.999E-10
+cgon_hvt       = 3.032E-11     cgln_hvt       = 1.287E-10     dvthn_hvt      = -0.038
+dlvthn_hvt     = -1.25E-09     dwvthn_hvt     = -1.00E-9      dpvthn_hvt     = -0.40E-16
+ddlcn_hvt      = 8.241E-09     ntoxn_hvt      = 1.5           cfn_hvt        = '1.562E-10 + 2.8e-11*ccoflag_hvt'
+dlvoffn_hvt    = 0.3e-9        dwvoffn_hvt    = 0e-9          deta0n_hvt     = 0.07
+dweta0n_hvt    = 7e-9          dlvsatn_hvt    = -4e-4         dpvsatn_hvt    = -1.0e-10
+dlatn_hvt      = -1.8e-4       dpatn_hvt      = -9e-11
+toxp_hvt       = 2.07E-09
+cjp_hvt        = 8.9E-04       cjswp_hvt      = 6.603E-11     cjswgp_hvt     = 2.883E-10
+cgop_hvt       = 7.462E-13     cglp_hvt       = 1.1861E-10    dvthp_hvt      = 0.035
+dlvthp_hvt     = 2.0E-10       dwvthp_hvt     = 3.0E-10       dpvthp_hvt     = 2.40E-16
+drdswp_hvt     = 30            du0p_hvt       = 0             dpu0p_hvt      = 0
+dlvsatp_hvt    = -1.40E-03     dpvsatp_hvt    = -1.8e-10      dppclmp_hvt    = 5e-16
+dpnfactorp_hvt = 0             dvoffp_hvt     = 0             dlvoffp_hvt    = -1.1e-9
+dpvoffp_hvt    = 0.8E-16       dleta0p_hvt    = -1e-9         dweta0p_hvt    = -8e-9
+dpa0p_hvt      = 0             dlk2p_hvt      = -8.0E-10      dlkt1p_hvt     = 0
+dpkt1p_hvt     = 0.8E-16       dlatp_hvt      = -2.6E-03      dpatp_hvt      = -2.1E-10
+ddlcp_hvt      = 6.0611E-09    ntoxp_hvt      = 1.7           cfp_hvt        = '1.5622E-10 + 2.8e-11*ccoflag_hvt'
.lib 'models.sp' MOS_hvt
.lib 'models.sp' FF_DIO_hvt
.ENDL FF_hvt

******************************   LIBRARY OF SNFP CORNER CASE   *******************************
.LIB SF_hvt
.param
+ccoflag_hvt=0
+toxn_hvt       = 1.93E-09      dxw_hvt        = 0             dxl_hvt        = 0
+cjn_hvt        = 9.812E-04     cjswn_hvt      = 9.630E-11     cjswgn_hvt     = 4.601E-10
+cgon_hvt       = 2.834E-11     cgln_hvt       = 1.203E-10     dvthn_hvt      = 0.032
+dlvthn_hvt     = 0.70E-9       dwvthn_hvt     = 0.90E-9       dpvthn_hvt     = 1.00E-16
+ddlcn_hvt      = 8.241E-09     ntoxn_hvt      = 1             cfn_hvt        = '1.460E-10 + 2.8e-11*ccoflag_hvt'
+dlvoffn_hvt    = 1e-10         dwvoffn_hvt    = 1e-10         deta0n_hvt     = -0.00
+dweta0n_hvt    = 1.4e-9        dlvsatn_hvt    = 0             dpvsatn_hvt    = 1.5e-10
+dlatn_hvt      = 5e-4          dpatn_hvt      = 0
+toxp_hvt       = 2.13E-09
+cjp_hvt        = 8.9E-04       cjswp_hvt      = 6.603E-11     cjswgp_hvt     = 2.883E-10
+cgop_hvt       = 6.974E-13     cglp_hvt       = 1.1085E-10    dvthp_hvt      = 0.035
+dlvthp_hvt     = 5.00E-10      dwvthp_hvt     = 3.0E-10       dpvthp_hvt     = 2.10E-16
+drdswp_hvt     = 0             du0p_hvt       = 0             dpu0p_hvt      = 0
+dlvsatp_hvt    = -0.40E-03     dpvsatp_hvt    = 0             dppclmp_hvt    = 0
+dpnfactorp_hvt = 0             dvoffp_hvt     = 0             dlvoffp_hvt    = -1.1e-9
+dpvoffp_hvt    = 0.8E-16       dleta0p_hvt    = -1e-9         dweta0p_hvt    = -8e-9
+dpa0p_hvt      = 0             dlk2p_hvt      = -7.0E-10      dlkt1p_hvt     = 0
+dpkt1p_hvt     = 0.8E-16       dlatp_hvt      = -2.6E-03      dpatp_hvt      = -2.1E-10
+ddlcp_hvt      = 6.0611E-09    ntoxp_hvt      = 1             cfp_hvt        = '1.46E-10 + 2.8e-11*ccoflag_hvt'
.lib 'models.sp' MOS_hvt
.ENDL SF_hvt

******************************   LIBRARY OF FNSP CORNER CASE   *******************************
.LIB FS_hvt
.param
+ccoflag_hvt=0
+toxn_hvt       = 1.93E-09      dxw_hvt        = 0             dxl_hvt        = 0
+cjn_hvt        = 8.528E-04     cjswn_hvt      = 8.370E-11     cjswgn_hvt     = 3.999E-10
+cgon_hvt       = 2.834E-11     cgln_hvt       = 1.203E-10     dvthn_hvt      = -0.032
+dlvthn_hvt     = -1.25E-09     dwvthn_hvt     = -1.00E-9      dpvthn_hvt     = -0.40E-16
+ddlcn_hvt      = 8.241E-09     ntoxn_hvt      = 1             cfn_hvt        = '1.460E-10 + 2.8e-11*ccoflag_hvt'
+dlvoffn_hvt    = 0.3e-9        dwvoffn_hvt    = 0e-9          deta0n_hvt     = 0.07
+dweta0n_hvt    = 7e-9          dlvsatn_hvt    = -4e-4         dpvsatn_hvt    = -1.0e-10
+dlatn_hvt      = -1.8e-4       dpatn_hvt      = -9e-11
+toxp_hvt       = 2.13E-09
+cjp_hvt        = 1.024E-03     cjswp_hvt      = 7.597E-11     cjswgp_hvt     = 3.317E-10
+cgop_hvt       = 6.974E-13     cglp_hvt       = 1.1085E-10    dvthp_hvt      = -0.04
+dlvthp_hvt     = -3.50E-10     dwvthp_hvt     = -3.00e-10     dpvthp_hvt     = -1.70E-16
+drdswp_hvt     = 0             du0p_hvt       = 1.5           dpu0p_hvt      = 0
+dlvsatp_hvt    = 1.40E-03      dpvsatp_hvt    = 1e-10         dppclmp_hvt    = 0
+dpnfactorp_hvt = 0             dvoffp_hvt     = 0             dlvoffp_hvt    = 0
+dpvoffp_hvt    = -0.6E-16      dleta0p_hvt    = 1e-9          dweta0p_hvt    = 3e-9
+dpa0p_hvt      = 0             dlk2p_hvt      = 9E-10         dlkt1p_hvt     = 0
+dpkt1p_hvt     = 0             dlatp_hvt      = 8.0e-3        dpatp_hvt      = 1.5e-10
+ddlcp_hvt      = 6.0611E-09    ntoxp_hvt      = 1             cfp_hvt        = '1.46E-10 + 2.8e-11*ccoflag_hvt'
.lib 'models.sp' MOS_hvt
.ENDL FS_hvt

***************************************************************
*                                                             *
*                       1.8V DEVICE LIB                       *
*                                                             *
***************************************************************
******************************     LIBRARY OF TYPICAL CASE     *******************************
.LIB TT_18
.param
+ccoflag_18=0
+toxn_18        = 3.4500E-09    dxl_18         = 0             dxw_18         = 0
+cjn_18         = 8.727E-04     cjswn_18       = 8.14259E-11   cjswgn_18      = 3.47696E-10
+cgon_18        = 7.18726e-11   cgln_18        = 3.71636e-11   dvthn_18       = 0
+dlvthn_18      = 0             dwvthn_18      = 0             dpvthn_18      = 0
+dlu0n_18       = 0             dvsatn_18      = 0             cfn_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
+toxp_18        = 3.77E-09
+cjp_18         = 9.547E-04     cjswp_18       = 6.6502E-11    cjswgp_18      = 2.72474E-10
+cgop_18        = 1.03e-10      cglp_18        = 4.06e-11      dvthp_18       = 0
+dlvthp_18      = 0             dwvthp_18      = 0             dvsatp_18      = 0
+du0p_18        = 0             drdswp_18      = 0             cfp_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
.lib 'models.sp' MOS_18
.ENDL TT_18

******************************   LIBRARY OF SNSP CORNER CASE   *******************************
.LIB SS_18
.param
+ccoflag_18=0
+toxn_18        = 3.5833E-09    dxl_18         = 8.00E-09      dxw_18         = -1.20E-08
+cjn_18         = 9.338E-04     cjswn_18       = 8.713E-11     cjswgn_18      = 3.720E-10
+cgon_18        = 6.6842E-11    cgln_18        = 3.4562E-11    dvthn_18       = 3E-2
+dlvthn_18      = 0.6e-9        dwvthn_18      = 0             dpvthn_18      = 7e-16
+dlu0n_18       = -0.73e-5      dvsatn_18      = 0.56e4        cfn_18         = '1.195E-10 + 2.4e-11*ccoflag_18'
+toxp_18        = 3.9033E-09
+cjp_18         = 1.022E-03     cjswp_18       = 7.116E-11     cjswgp_18      = 2.915E-10
+cgop_18        = 9.62E-11      cglp_18        = 3.77E-11      dvthp_18       = -3E-2
+dlvthp_18      = -2.2E-9       dwvthp_18      = -6E-9         dvsatp_18      = 5e4
+du0p_18        = -2.4          drdswp_18      = -10           cfp_18         = '1.195E-10 + 2.4e-11*ccoflag_18'
.lib 'models.sp' MOS_18
.ENDL SS_18

******************************   LIBRARY OF FNFP CORNER CASE   *******************************
.LIB FF_18
.param
+ccoflag_18=0
+toxn_18        = 3.3167E-09    dxl_18         = -8.00E-09     dxw_18         = 1.20E-08
+cjn_18         = 8.116E-04     cjswn_18       = 7.573E-11     cjswgn_18      = 3.234E-10
+cgon_18        = 7.6904E-11    cgln_18        = 3.9765E-11    dvthn_18       = -3E-2
+dlvthn_18      = -0.2e-9       dwvthn_18      = 0             dpvthn_18      = -5e-16
+dlu0n_18       = 0.745e-5      dvsatn_18      = -0.4e4        cfn_18         = '1.375E-10 + 2.4e-11*ccoflag_18'
+toxp_18        = 3.6367E-09
+cjp_18         = 8.879E-04     cjswp_18       = 6.185E-11     cjswgp_18      = 2.534E-10
+cgop_18        = 1.11E-10      cglp_18        = 4.34E-11      dvthp_18       = 3E-2
+dlvthp_18      = 1.8E-9        dwvthp_18      = 4.3E-9        dvsatp_18      = -2.5e4
+du0p_18        = 1.6           drdswp_18      = 0             cfp_18         = '1.375E-10 + 2.4e-11*ccoflag_18'
.lib 'models.sp' MOS_18
.ENDL FF_18

******************************   LIBRARY OF SNFP CORNER CASE   *******************************
.LIB SF_18
.param
+ccoflag_18=0
+toxn_18        = 3.4500E-09    dxl_18         = 0             dxw_18         = 0
+cjn_18         = 9.338E-04     cjswn_18       = 8.713E-11     cjswgn_18      = 3.720E-10
+cgon_18        = 7.1873E-11    cgln_18        = 3.7164E-11    dvthn_18       = 3E-2
+dlvthn_18      = 0.6e-9        dwvthn_18      = 0             dpvthn_18      = 7e-16
+dlu0n_18       = 0             dvsatn_18      = 0             cfn_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
+toxp_18        = 3.7700E-09
+cjp_18         = 8.879E-04     cjswp_18       = 6.185E-11     cjswgp_18      = 2.534E-10
+cgop_18        = 1.03e-10      cglp_18        = 4.06e-11      dvthp_18       = 3E-2
+dlvthp_18      = 1.8E-9        dwvthp_18      = 4.3E-9        dvsatp_18      = 0
+du0p_18        = 0             drdswp_18      = 0             cfp_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
.lib 'models.sp' MOS_18
.ENDL SF_18

******************************   LIBRARY OF FNSP CORNER CASE   *******************************
.LIB FS_18
.param
+ccoflag_18=0
+toxn_18        = 3.4500E-09    dxl_18         = 0             dxw_18         = 0
+cjn_18         = 8.116E-04     cjswn_18       = 6.185E-11     cjswgn_18      = 3.234E-10
+cgon_18        = 7.1873E-11    cgln_18        = 3.7164E-11    dvthn_18       = -3E-2
+dlvthn_18      = -0.2e-9       dwvthn_18      = 0             dpvthn_18      = -5e-16
+dlu0n_18       = 0             dvsatn_18      = 0             cfn_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
+toxp_18        = 3.7700E-09
+cjp_18         = 1.022E-03     cjswp_18       = 7.116E-11     cjswgp_18      = 2.915E-10
+cgop_18        = 1.03e-10      cglp_18        = 4.06e-11      dvthp_18       = -3E-2
+dlvthp_18      = -2.2E-9       dwvthp_18      = -6E-9         dvsatp_18      = 0
+du0p_18        = 0             drdswp_18      = 0             cfp_18         = '1.285E-10 + 2.4e-11*ccoflag_18'
.lib 'models.sp' MOS_18
.ENDL FS_18

**********************************************************************************************
***************************************************************
*                                                             *
*               1.05V STANDARD VT DEVICE LIB                  *
*                                                             *
***************************************************************

.LIB MOS
.MODEL nch.1 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.122+dvthn'       K1         = 0.158               K2         = 0.03
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 36.248463           LDVT0      = -1.1236167e-005     DVT1       = 1.8
+DVT2       = 0.08                DVT0W      = -2e-006             DVT1W      = 10000
+DVT2W      = 0                   DSUB       = 0.5                 MINV       = 0
+VOFFL      = 0                   DVTP0      = 8.5e-007            DVTP1      = 2.5
+LPE0       = 9e-008              LPEB       = 4e-008              XJ         = 1.4e-007
+NGATE      = 4e+020              NDEP       = 8.5e+017            NSD        = 1e+020
+PHIN       = 0                   CDSC       = 0                   CDSCB      = 0
+CDSCD      = 0                   CIT        = 0                   VOFF       = -0.1037
+NFACTOR    = 0.53045174          LNFACTOR   = -5.168637e-011      ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 288.5               UA         = -9.452e-010
+UB         = 2.127e-018          UC         = 1.45e-010           VSAT       = 104255.01
+LVSAT      = '4.4944669e-005+dlvsatn'
+A0         = 4.5215411           LA0        = -5.4045965e-010     AGS        = 0.85301554
+LAGS       = 5.6137016e-007      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.06
+DWG        = 0                   DWB        = 0                   PCLM       = 0.2
+PDIBLC1    = 0.0001              PDIBLC2    = 0.002               PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0099749693
+LAIGC      = -2.2472335e-010     BIGC       = 0.0016              CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.26
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.27
+UA1        = 3.281099e-009       UB1        = -3.964452e-018      UC1        = -2e-010
+PRT        = 0                   AT         = 200000              JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn'          WVTH0      = '0+dwvthn'
+PVTH0      = '0+dpvthn'          LVOFF      = '0+dlvoffn'         WVOFF      = '0+dwvoffn'
+WETA0      = '0+dweta0n'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.2 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.122+dvthn'       K1         = 0.158               K2         = 0.03
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 25                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.099133826        LVOFF      = '-4.5611825e-009+dlvoffn'
+NFACTOR    = 0.51249579          LNFACTOR   = 1.7884637e-008      ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 296.25048           LU0        = -7.7420071e-006
+UA         = -7.7048377e-010     LUA        = -1.7452525e-016     UB         = 2.0494952e-018
+LUB        = 7.7420071e-026      UC         = 1.45e-010           VSAT       = 104300
+A0         = 5.0833603           LA0        = -5.6174563e-007     AGS        = 1.232353
+LAGS       = 1.824473e-007       A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.06
+DWG        = 0                   DWB        = 0                   PCLM       = 0.079837532
+LPCLM      = 1.2003112e-007      PDIBLC1    = 0.0001              PDIBLC2    = 0.0015193501
+LPDIBLC2   = 4.8012447e-010      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.2
+PDITSD     = 0.5                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.93                BETA0      = 11.6
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.00975             BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon'              CGDO       = 'cgon'
+CGBO       = 0                   CGDL       = 'cgln'              CGSL       = 'cgln'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.053
+KT1        = -0.26               KT1L       = 0                   KT2        = -0.026
+UTE        = -1.1696643          LUTE       = -1.0022598e-007     UA1        = 4.2371693e-009
+LUA1       = -9.5502519e-016     UB1        = -5.0758016e-018     LUB1       = 1.1101348e-024
+UC1        = -2e-010             PRT        = 0                   AT         = 260081.23
+LAT        = -0.060015559        JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn'          WVTH0      = '0+dwvthn'          PVTH0      = '0+dpvthn'
+WVOFF      = '0+dwvoffn'         WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'
+PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.3 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1274822+dvthn'   LVTH0      = '-2.0553162e-009+dlvthn'
+K1         = 0.158               K2         = 0.032463912         LK2        = -9.2373764e-010
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 25                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.099781211        LVOFF      = '-4.3184734e-009+dlvoffn'
+NFACTOR    = 0.61576122          LNFACTOR   = -2.0830284e-008     ETA0       = '0.18615978+deta0n'
+LETA0      = -2.3093441e-009     ETAB       = -0.08               U0         = 294.32573
+LU0        = -7.020406e-006      UA         = -1.1084926e-009     LUA        = -4.7803423e-017
+UB         = 2.2861829e-018      LUB        = -1.1315786e-026     UC         = 1.4937344e-010
+LUC        = -1.6396343e-018     VSAT       = 115572.4            LVSAT      = '-0.0042260997+dlvsatn'
+A0         = 5.7871153           LA0        = -8.255882e-007      AGS        = 2.7772502
+LAGS       = -3.9674531e-007     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.090798901
+LKETA      = 1.154672e-008       DWG        = 0                   DWB        = 0
+PCLM       = 0.4615978           LPCLM      = -2.3093441e-008     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0026768044        LPDIBLC2   = 4.6186882e-011      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.00975
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.25384022         LKT1       = -2.3093441e-009
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.3586328
+LUTE       = -2.9380399e-008     UA1        = 1.7200149e-009      LUA1       = -1.132664e-017
+UB1        = -1.7651512e-018     LUB1       = -1.3105089e-025     UC1        = -2e-010
+PRT        = 0                   AT         = 135644.78           LAT        = -0.013363475
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 4.5E-13
+JSWD       = 4.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn'               CJD        = 'cjn'               MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn'             CJSWD      = 'cjswn'             MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.5                 PBSWGD     = 0.5
+CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'            MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.14E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03
+TCJSWG     = 8.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthn'
+PVTH0      = '0+dpvthn'          WVOFF      = '0+dwvoffn'         WETA0      = '0+dweta0n'
+PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.4 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.2070400E-09
+LL         = 4.3827800E-03       WL         = 0                   LLN        = -0.84142000
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.3827800E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.2070400E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.10129724+dvthn'  LVTH0      = '1.686696e-009+dlvthn'
+K1         = 0.158               K2         = 0.017141146         LK2        = 1.2659914e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 25                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11439865         LVOFF      = '-2.2295407e-009+dlvoffn'
+NFACTOR    = -0.059089288        LNFACTOR   = 7.561051e-008       ETA0       = '0.1632168+deta0n'
+LETA0      = 9.6936551e-010      ETAB       = -0.082713278        LETAB      = 3.8774621e-010
+U0         = 258.90206           LU0        = -1.9581183e-006     UA         = -1.6180065e-009
+LUA        = 2.500963e-017       UB         = 2.4450902e-018      LUB        = -3.402473e-026
+UC         = 1.6733907e-010      LUC        = -4.2070463e-018     VSAT       = 73179.76
+LVSAT      = '0.0018321008+dlvsatn'
+A0         = 0.010491607         LA0        = -6.8824951e-011     AGS        = -0.0051048764
+LAGS       = 8.7242896e-010      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.030349588
+LKETA      = 2.9080965e-009      DWG        = 0                   DWB        = 0
+PCLM       = 0.36783196          LPCLM      = -9.6936551e-009     PDIBLC1    = 0.0001
+PDIBLC2    = 0.002586225         LPDIBLC2   = 5.9131296e-011      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.00975
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.27               KT1L       = 0
+KT2        = -0.026              UTE        = -1.7740974          LUTE       = 2.9992363e-008
+UA1        = 2.2541472e-009      LUA1       = -8.7657833e-017     UB1        = -3.8232491e-018
+LUB1       = 1.630655e-025       UC1        = -2e-010             PRT        = 0
+AT         = 39170.829           LAT        = 0.00042331901       JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  WVTH0      = '0+dwvthn'          PVTH0      = '0+dpvthn'
+WVOFF      = '0+dwvoffn'         WETA0      = '0+dweta0n'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.5 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.6064050E-09
+LL         = 5.4893200E-03       WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.4893200E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.6064050E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1675353+dvthn'   LVTH0      = '-2.1390883e-009+dlvthn'
+K1         = 0.158               K2         = 0.049853143         LK2        = -6.2339144e-010
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 25                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.075402239        LVOFF      = '-4.4818993e-009+dlvoffn'
+NFACTOR    = -1.3953782          LNFACTOR   = 1.5279202e-007      ETA0       = '0.33519552+deta0n'
+LETA0      = -8.9637985e-009     ETAB       = -0.076              U0         = 300.83418
+LU0        = -4.3800379e-006     UA         = -1.5130269e-009     LUA        = 1.8946211e-017
+UB         = 2.1558095e-018      LUB        = -1.7316429e-026     UC         = 5.7464705e-011
+LUC        = 2.1390883e-018      VSAT       = 99256.526           LVSAT      = '0.00032595631+dlvsatn'
+A0         = 0.0068309803        LA0        = 1.4260589e-010      AGS        = -4.5400506
+LAGS       = 2.6280228e-007      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = 0.069380394
+LKETA      = -2.8521177e-009     DWG        = 0                   DWB        = 0
+PCLM       = -0.57597761         LPCLM      = 4.4818993e-008      PDIBLC1    = 0.0001
+PDIBLC2    = -0.011874281        LPDIBLC2   = 8.9434263e-010      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.00975
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.27               KT1L       = 0
+KT2        = -0.026              UTE        = -2.2668876          LUTE       = 5.8454988e-008
+UA1        = 5.8139708e-010      LUA1       = 8.9570349e-018      UB1        = -1e-018
+UC1        = -7.2907565e-010     LUC1       = 3.0558404e-017      PRT        = 0
+AT         = 34154.902           LAT        = 0.00071302943       JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  WVTH0      = '0+dwvthn'          PVTH0      = '0+dpvthn'
+WVOFF      = '0+dwvoffn'         WETA0      = '0+dweta0n'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.6 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12133481+dvthn'  WVTH0      = '5.9853363e-009+dwvthn'
+K1         = 0.158               K2         = 0.029606432         WK2        = 3.541324e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 36.386873           LDVT0      = -1.2481856e-005     WDVT0      = -1.2454119e-006
+PDVT0      = 1.1208707e-011      DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.10388847         WVOFF      = '1.6958453e-009+dwvoffn'
+NFACTOR    = 0.46176602          LNFACTOR   = -5.7416538e-011     WNFACTOR   = 6.1803411e-007
+PNFACTOR   = 5.1560051e-017      ETA0       = '0.18+deta0n'       ETAB       = -0.08
+U0         = 277.92177           WU0        = 9.5182908e-005      UA         = -1.0920992e-009
+WUA        = 1.3217988e-015      UB         = 2.2469551e-018      WUB        = -1.0793556e-024
+UC         = 1.472062e-010       WUC        = -1.9851365e-017     VSAT       = 104726.73
+LVSAT      = '4.9927424e-005+dlvsatn'
+WVSAT      = -0.0042446071       PVSAT      = '-4.4834827e-011+dpvsatn'
+A0         = 4.5166121           LA0        = -6.0037727e-010     WA0        = 4.4350293e-008
+PA0        = 5.3913879e-016      AGS        = 0.85982893          LAGS       = 5.7626984e-007
+WAGS       = -6.1306935e-008     PAGS       = -1.3406734e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.066962272        WKETA      = 6.264652e-008       DWG        = 0
+DWB        = 0                   PCLM       = 0.13807126          WPCLM      = 5.5723481e-007
+PDIBLC1    = 0.0001              PDIBLC2    = 0.0017439514        WPDIBLC2   = 2.3039255e-009
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0099521044        LAIGC      = -2.184949e-010      WAIGC      = 2.0573827e-010
+PAIGC      = -5.6043534e-017     BIGC       = 0.0015623062        WBIGC      = 3.3916906e-010
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon'              CGDO       = 'cgon'
+CGBO       = 0                   CGDL       = 'cgln'              CGSL       = 'cgln'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.053
+KT1        = -0.26188469         WKT1       = 1.6958453e-008      KT1L       = 0
+KT2        = -0.026              UTE        = -1.2463233          WUTE       = -2.1304306e-007
+UA1        = 3.3213817e-009      WUA1       = -3.6246399e-016     UB1        = -3.9618674e-018
+WUB1       = -2.3256024e-026     UC1        = -2e-010             PRT        = 0
+AT         = 202217.28           WAT        = -0.019951121        JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn'          PVTH0      = '0+dpvthn'
+LVOFF      = '0+dlvoffn'         WETA0      = '0+dweta0n'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.7 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12093516+dvthn'  LVTH0      = '3.9921461e-010+dlvthn'
+WVTH0      = '9.5814002e-009+dwvthn'
+PVTH0      = '-3.592133e-015+dpvthn'
+K1         = 0.158               K2         = 0.029966118         LK2        = -3.5929315e-010
+WK2        = 3.0486646e-010      PK2        = 3.2329197e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 23.891358
+WDVT0      = 9.9755605e-006      DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.099181771        LVOFF      = '-4.701553e-009+dlvoffn'
+WVOFF      = '4.3140928e-010+dwvoffn'
+PVOFF      = 1.2630538e-015      NFACTOR    = 0.43145178          LNFACTOR   = 3.0223688e-008
+WNFACTOR   = 7.2923401e-007      PNFACTOR   = -1.1102679e-013     ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 278.54916           LU0        = -6.2669871e-007
+WU0        = 0.00015927651       PU0        = -6.4023545e-011     UA         = -9.9934341e-010
+LUA        = -9.2654374e-017     WUA        = 2.059279e-015       PUA        = -7.3667411e-022
+UB         = 2.232088e-018       LUB        = 1.4850833e-026      WUB        = -1.6429697e-024
+PUB        = 5.6299801e-031      UC         = 1.4921112e-010      LUC        = -2.0027266e-018
+WUC        = -3.7891619e-017     PUC        = 1.8020534e-023      VSAT       = 104776.72
+WVSAT      = -0.004289491        A0         = 5.1075621           LA0        = -5.9090434e-007
+WA0        = -2.1776708e-007     PA0        = 2.6237e-013         AGS        = 1.2729901
+LAGS       = 1.6356032e-007      WAGS       = -3.6565197e-007     PAGS       = 1.6994501e-013
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.067521784        LKETA      = 5.5890045e-010
+WKETA      = 6.7681009e-008      PKETA      = -5.0289863e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.0091564242        LPCLM      = 1.2877392e-007
+WPCLM      = 6.3598861e-007      PPCLM      = -7.8667714e-014     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0011633933        LPDIBLC2   = 5.7992347e-010      WPDIBLC2   = 3.2028995e-009
+PPDIBLC2   = -8.9799135e-016     PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.2
+PDITSD     = 0.5                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.93                BETA0      = 11.6
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097333704        WAIGC      = 1.4963341e-010
+BIGC       = 0.0015623062        WBIGC      = 3.3916906e-010      CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.26235095
+LKT1       = 4.6575038e-010      WKT1       = 2.1153861e-008      PKT1       = -4.1908219e-015
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.1099965
+LUTE       = -1.3617772e-007     WUTE       = -5.3689079e-007     PUTE       = 3.2349373e-013
+UA1        = 4.3235602e-009      LUA1       = -1.001083e-015      WUA1       = -7.7734547e-016
+PUA1       = 4.1442798e-022      UB1        = -5.0679733e-018     LUB1       = 1.1048968e-024
+WUB1       = -7.0439379e-026     PUB1       = 4.7131779e-032      UC1        = -2e-010
+PRT        = 0                   AT         = 264296.78           LAT        = -0.062011632
+WAT        = -0.037931441        PAT        = 1.7960665e-008      JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'
+PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.8 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12808998+dvthn'  LVTH0      = '-2.2831772e-009+dlvthn'
+WVTH0      = '-5.4688061e-009+dwvthn'
+PVTH0      = '2.0502931e-015+dpvthn'
+K1         = 0.158               K2         = 0.031601428         LK2        = -9.7238212e-010
+WK2        = 7.7606287e-009      PK2        = 4.3770303e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 23.891358
+WDVT0      = 9.9755605e-006      DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.10072324         LVOFF      = '-4.1236472e-009+dlvoffn'
+WVOFF      = '8.4763414e-009+dwvoffn'
+PVOFF      = -1.7530467e-015     NFACTOR    = 0.55710262          LNFACTOR   = -1.6883678e-008
+WNFACTOR   = 5.2781007e-007      PNFACTOR   = -3.5511561e-014     ETA0       = '0.18684268+deta0n'
+LETA0      = -2.5653677e-009     WETA0      = '-6.144726e-009+dweta0n'
+PETA0      = 2.3037002e-015      ETAB       = -0.08               U0         = 294.66931
+LU0        = -6.6702554e-006     WU0        = -3.0915027e-006     PU0        = -3.1506555e-012
+UA         = -1.1293255e-009     LUA        = -4.392318e-017      WUA        = 1.8745514e-016
+PUA        = -3.4914419e-023     UB         = 2.3076613e-018      LUB        = -1.348213e-026
+WUB        = -1.932625e-025      PUB        = 1.9492759e-032      UC         = 1.4767582e-010
+LUC        = -1.4271347e-018     WUC        = 1.5275194e-017      PUC        = -1.9120711e-024
+VSAT       = 117298.82           LVSAT      = '-0.0046946228+dlvsatn'
+WVSAT      = -0.01553434         PVSAT      = '4.2157713e-009+dpvsatn'
+A0         = 5.8957014           LA0        = -8.863832e-007      WA0        = -9.7705804e-007
+PA0        = 5.4703342e-013      AGS        = 2.7615094           LAGS       = -3.9449584e-007
+WAGS       = 1.4163606e-007      PAGS       = -2.024077e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.1000532          LKETA      = 1.2755152e-008      WKETA      = 8.3270156e-008
+PKETA      = -1.0873465e-014     DWG        = 0                   DWB        = 0
+PCLM       = 0.41237913          LPCLM      = -2.2397057e-008     WPCLM      = 4.428696e-007
+PPCLM      = -6.2660645e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.002600044
+LPDIBLC2   = 4.1313217e-011      WPDIBLC2   = 6.9069028e-010      PPDIBLC2   = 4.3853236e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097333704        WAIGC      = 1.4963341e-010      BIGC       = 0.0015623062
+WBIGC      = 3.3916906e-010      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.25474399         LKT1       = -2.3861512e-009
+WKT1       = 8.1321427e-009      PKT1       = 6.9111005e-016      KT1L       = 0
+KT2        = -0.026              UTE        = -1.3863613          LUTE       = -3.2566664e-008
+WUTE       = 2.4950104e-007      PUTE       = 2.8670009e-014      UA1        = 1.6713437e-009
+LUA1       = -6.7487079e-018     WUA1       = 4.3794348e-016      PUA1       = -4.1192232e-023
+UB1        = -1.7566956e-018     LUB1       = -1.3652406e-025     WUB1       = -7.6082918e-026
+PUB1       = 4.9247581e-032      UC1        = -2e-010             PRT        = 0
+AT         = 135073.37           LAT        = -0.013564887        WAT        = 0.005141523
+PAT        = 1.812314e-009       JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.9 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.2070400E-09
+LL         = 4.3827800E-03       WL         = 0                   LLN        = -0.84142000
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.3827800E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.2070400E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.099618695+dvthn' LVTH0      = '1.7855665e-009+dlvthn'
+WVTH0      = '1.5103538e-008+dwvthn'
+PVTH0      = '-8.8963672e-016+dpvthn'
+K1         = 0.158               K2         = 0.015193024         LK2        = 1.3724921e-009
+WK2        = 1.7529202e-008      PK2        = -9.5829346e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 23.891358
+WDVT0      = 9.9755605e-006      DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11318399         LVOFF      = '-2.3429193e-009+dlvoffn'
+WVOFF      = '-1.0929495e-008+dwvoffn'
+PVOFF      = 1.0201812e-015      NFACTOR    = -0.15743648         LNFACTOR   = 8.522889e-008
+WNFACTOR   = 8.8492802e-007      PNFACTOR   = -8.6546181e-014     ETA0       = '0.15992732+deta0n'
+LETA0      = 1.2810225e-009      WETA0      = '2.9598753e-008+dweta0n'
+PETA0      = -2.8042897e-015     ETAB       = -0.081961265        LETAB      = 2.8027828e-010
+WETAB      = -6.7666182e-009     PETAB      = 9.6699643e-016      U0         = 261.71315
+LU0        = -1.9605933e-006     WU0        = -2.5294248e-005     PU0        = 2.2269928e-014
+UA         = -1.6085287e-009     LUA        = 2.4558265e-017      WUA        = -8.5280491e-017
+PUA        = 4.061385e-024       UB         = 2.4439645e-018      LUB        = -3.2960797e-026
+WUB        = 1.0128825e-026      PUB        = -9.5732647e-033     UC         = 1.6665466e-010
+LUC        = -4.1393415e-018     WUC        = 6.158326e-018       PUC        = -6.0920775e-025
+VSAT       = 70206.355           LVSAT      = '0.0020352152+dlvsatn'
+WVSAT      = 0.026754693         PVSAT      = '-1.8276233e-009+dpvsatn'
+A0         = -0.34080711         LA0        = 4.8568924e-009      WA0        = 3.1609858e-006
+PA0        = -4.4321605e-014     AGS        = -0.0051048764       LAGS       = 8.7242896e-010
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.03168926         LKETA      = 2.9854734e-009
+WKETA      = 1.2054369e-008      PKETA      = -6.9623743e-016     DWG        = 0
+DWB        = 0                   PCLM       = 0.30372336          LPCLM      = -6.8693979e-009
+WPCLM      = 5.7684915e-007      PPCLM      = -2.5412666e-014     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0022038839        LPDIBLC2   = 9.7927219e-011      WPDIBLC2   = 3.4403052e-009
+PPDIBLC2   = -3.4908571e-016     PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.2
+PDITSD     = 0.5                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.93                BETA0      = 11.6
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097333704        WAIGC      = 1.4963341e-010
+BIGC       = 0.0015623062        WBIGC      = 3.3916906e-010      CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.2693356
+LKT1       = -3.009102e-010      WKT1       = -5.9783023e-009     PKT1       = 2.70759e-015
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.8320102
+LUTE       = 3.1119633e-008      WUTE       = 5.2109873e-007      PUTE       = -1.0143174e-014
+UA1        = 2.2516224e-009      LUA1       = -8.9674539e-017     WUA1       = 2.271826e-017
+PUA1       = 1.8146317e-023      UB1        = -3.8733357e-018     LUB1       = 1.6595841e-025
+WUB1       = 4.5067936e-025      PUB1       = -2.6030384e-032     UC1        = -1.890958e-010
+LUC1       = -1.558285e-018      WUC1       = -9.8115964e-017     PUC1       = 1.4021448e-023
+PRT        = 0                   AT         = 34605.579           LAT        = 0.00079265372
+WAT        = 0.041078121         PAT        = -3.3232737e-009     JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.10 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.6064050E-09
+LL         = 5.4893200E-03       WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.4893200E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.6064050E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.17843938+dvthn'  LVTH0      = '-2.7669667e-009+dlvthn'
+WVTH0      = '-9.8114977e-008+dwvthn'
+PVTH0      = '5.6496496e-015+dpvthn'
+K1         = 0.158               K2         = 0.052900689         LK2        = -8.05431e-010
+WK2        = -2.7421816e-008     PK2        = 1.6379919e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 23.891358
+WDVT0      = 9.9755605e-006      DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.080276012        LVOFF      = '-4.2436217e-009+dlvoffn'
+WVOFF      = '4.3854214e-008+dwvoffn'
+PVOFF      = -2.1440217e-015     NFACTOR    = -1.1942442          LNFACTOR   = 1.4511293e-007
+WNFACTOR   = -1.8098042e-006     PNFACTOR   = 6.9096434e-014      ETA0       = '0.34629579+deta0n'
+LETA0      = -9.4832662e-009     WETA0      = '-9.9880232e-008+dweta0n'
+PETA0      = 4.6741705e-015      ETAB       = -0.077108642        WETAB      = 9.9755605e-009
+U0         = 290.1389            LU0        = -3.6024106e-006     WU0        = 9.6236082e-005
+PU0        = -6.997091e-012      UA         = -1.6001293e-009     LUA        = 2.4073131e-017
+WUA        = 7.8374768e-016      PUA        = -4.6132031e-023     UB         = 2.1109295e-018
+LUB        = -1.3725326e-026     WUB        = 4.0383082e-025      PUB        = -3.2312744e-032
+UC         = 3.6210851e-011      LUC        = 3.394845e-018       WUC        = 1.9124217e-016
+PUC        = -1.1299299e-023     VSAT       = 101129.29           LVSAT      = '0.00024916543+dlvsatn'
+WVSAT      = -0.016851097        PVSAT      = '6.9096434e-010+dpvsatn'
+A0         = -0.78688404         LA0        = 3.0621448e-008      WA0        = 7.1418477e-006
+PA0        = -2.7424862e-013     AGS        = -4.5791543          LAGS       = 2.6506083e-007
+WAGS       = 3.5185507e-007      PAGS       = -2.0322481e-014     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.11849464          LKETA      = -5.6888632e-009     WKETA      = -4.4192997e-007
+PKETA      = 2.5525036e-014      DWG        = 0                   DWB        = 0
+PCLM       = -0.61973388         LPCLM      = 4.6467738e-008      WPCLM      = 3.9371889e-007
+PPCLM      = -1.4835411e-014     PDIBLC1    = 0.0001              PDIBLC2    = -0.013301577
+LPDIBLC2   = 9.934932e-010       WPDIBLC2   = 1.2842816e-008      PPDIBLC2   = -8.921569e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097333704        WAIGC      = 1.4963341e-010      BIGC       = 0.0015623062
+WBIGC      = 3.3916906e-010      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.29683454         LKT1       = 1.2873765e-009
+WKT1       = 2.4145719e-007      PKT1       = -1.1583814e-014     KT1L       = 0
+KT2        = -0.026              UTE        = -2.4532683          LUTE       = 6.7002321e-008
+WUTE       = 1.6770531e-006      PUTE       = -7.6908903e-014     UA1        = 4.3150778e-010
+LUA1       = 1.5451822e-017      WUA1       = 1.3487039e-015      PUA1       = -5.8440097e-023
+UB1        = -1e-018             UC1        = -8.0185132e-010     LUC1       = 3.3833309e-017
+WUC1       = 6.5483548e-016      PUC1       = -2.9467597e-023     PRT        = 0
+AT         = 40578.845           LAT        = 0.00044764918       WAT        = -0.057802646
+PAT        = 2.3878915e-009      JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.11 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.13995556+dvthn'  WVTH0      = '-1.0736089e-008+dwvthn'
+K1         = 0.158               K2         = 0.03355             K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.087055556        WVOFF      = '-1.3420111e-008+dwvoffn'
+NFACTOR    = 2.075889            WNFACTOR   = -8.3144835e-007     ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 546.68516           WU0        = -0.00014616662
+UA         = 2.4867603e-009      WUA        = -1.8920171e-015     UB         = -9.0525e-019
+WUB        = 1.7513245e-024      UC         = 8.0117222e-011      WUC        = 4.0394534e-017
+VSAT       = 100000              A0         = 3.454634            WA0        = 9.9800669e-007
+AGS        = 0.87996254          LAGS       = 5.7554146e-008      WAGS       = -7.9386918e-008
+PAGS       = 3.3173935e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = 0.041057778
+WKETA      = -3.4355484e-008     DWG        = 0                   DWB        = 0
+PCLM       = -0.34938111         WPCLM      = 9.9496704e-007      PDIBLC1    = 0.0001
+PDIBLC2    = 0.0062666496        WPDIBLC2   = -1.7574575e-009     PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.011021814
+LAIGC      = -4.4882246e-010     WAIGC      = -7.5486062e-010     PAIGC      = 1.5079061e-016
+BIGC       = 0.0026243734        WBIGC      = -6.1456728e-010     CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.21759444
+WKT1       = -2.2814189e-008     KT1L       = 0                   KT2        = -0.026
+UTE        = -1.0830644          WUTE       = -3.5964958e-007     UA1        = 5.0353135e-009
+WUA1       = -1.9015747e-015     UB1        = -5.6900598e-018     WUB1       = 1.5286607e-024
+UC1        = -2e-010             PRT        = 0                   AT         = 157583.33
+WAT        = 0.020130167         JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn'          PVTH0      = '0+dpvthn'          LVOFF      = '0+dlvoffn'
+WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.12 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.15074347+dvthn'  LVTH0      = '-1.0776127e-008+dlvthn'
+WVTH0      = '-1.7186464e-008+dwvthn'
+PVTH0      = '6.4433238e-015+dpvthn'
+K1         = 0.158               K2         = 0.030305613         LK2        = 3.2408402e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 35                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.068052713        LVOFF      = '-1.898207e-008+dlvoffn'
+WVOFF      = '-2.7522485e-008+dwvoffn'
+PVOFF      = 1.4086958e-014      NFACTOR    = 2.5511878           LNFACTOR   = -4.7477919e-007
+WNFACTOR   = -1.1742889e-006     PNFACTOR   = 3.424658e-013       ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 715.85896           LU0        = -0.00016898887
+WU0        = -0.00023342769      PU0        = 8.7165687e-011      UA         = 4.5730483e-009
+LUA        = -2.0840075e-015     WUA        = -2.9447288e-015     PUA        = 1.051561e-021
+UB         = -2.5577802e-018     LUB        = 1.6507238e-024      WUB        = 2.6583318e-024
+PUB        = -9.0601589e-031     UC         = 3.5006563e-011      LUC        = 4.5061349e-017
+WUC        = 6.4664069e-017      PUC        = -2.4243006e-023     VSAT       = 100000
+A0         = 2.8826202           LA0        = 5.7138852e-007      WA0        = 1.7802307e-006
+PA0        = -7.8136899e-013     AGS        = 0.49426644          LAGS       = 4.4282864e-007
+WAGS       = 3.3364186e-007      PAGS       = -8.083794e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.051132733         LKETA      = -1.0063942e-008     WKETA      = -3.8870747e-008
+PKETA      = 4.5103266e-015      DWG        = 0                   DWB        = 0
+PCLM       = -1.1794748          LPCLM      = 8.291863e-007       WPCLM      = 1.7033794e-006
+PPCLM      = -7.0763803e-013     PDIBLC1    = 0.0001              PDIBLC2    = 0.0073156298
+LPDIBLC2   = -1.0478336e-009     WPDIBLC2   = -2.3218088e-009     PPDIBLC2   = 5.6373445e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0105725           WAIGC      = -6.03905e-010       BIGC       = 0.0026243734
+WBIGC      = -6.1456728e-010     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.20710359         LKT1       = -1.0479383e-008
+WKT1       = -2.8458267e-008     PKT1       = 5.6379083e-015      KT1L       = 0
+KT2        = -0.026              UTE        = -1.1195098          LUTE       = 3.6405658e-008
+WUTE       = -5.2834785e-007     PUTE       = 1.6851386e-013      UA1        = 6.8461711e-009
+LUA1       = -1.8088781e-015     WUA1       = -3.04265e-015       PUA1       = 1.139828e-021
+UB1        = -7.8688202e-018     LUB1       = 2.1763788e-024      WUB1       = 2.4447211e-024
+PUB1       = -9.150591e-031      UC1        = -2e-010             PRT        = 0
+AT         = 172829.48           LAT        = -0.015229482        WAT        = 0.04420619
+PAT        = -2.4049706e-008     JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.13 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12660272+dvthn'  LVTH0      = '-1.7255932e-009+dlvthn'
+WVTH0      = '-4.1332467e-009+dwvthn'
+PVTH0      = '1.5495827e-015+dpvthn'
+K1         = 0.158               K2         = 0.033937821         LK2        = 1.8791005e-009
+WK2        = 5.662548e-009       PK2        = -2.1229283e-015     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10955721         LVOFF      = '-3.4217491e-009+dlvoffn'
+WVOFF      = '1.6409247e-008+dwvoffn'
+PVOFF      = -2.3833512e-015     NFACTOR    = 1.3583063           LNFACTOR   = -2.7559706e-008
+WNFACTOR   = -1.9167086e-007     PNFACTOR   = -2.5924488e-014     ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 302.10231           LU0        = -1.3868651e-005
+WU0        = -9.766339e-006      PU0        = 3.3135037e-012      UA         = -5.5841291e-010
+LUA        = -1.6018726e-016     WUA        = -3.2522439e-016     PUA        = 6.9490727e-023
+UB         = 1.6529167e-018      LUB        = 7.2104464e-026      WUB        = 3.9469815e-025
+PUB        = -5.7364002e-032     UC         = 1.4185655e-010      LUC        = 5.0025525e-018
+WUC        = 2.0500904e-017      PUC        = -7.6859303e-024     VSAT       = 100000
+A0         = 4.1260099           LA0        = 1.0523312e-007      WA0        = 6.1212488e-007
+PA0        = -3.4343805e-013     AGS        = 2.7151368           LAGS       = -3.8979097e-007
+WAGS       = 1.8327866e-007      PAGS       = -2.4465742e-014     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.051285152         LKETA      = -1.0121085e-008     WKETA      = -5.2631682e-008
+PKETA      = 9.6693961e-015      DWG        = 0                   DWB        = 0
+PCLM       = 1.05278             LPCLM      = -7.7014059e-009     WPCLM      = -1.3221035e-007
+PPCLM      = -1.9462759e-014     PDIBLC1    = 0.0001              PDIBLC2    = 0.003920916
+LPDIBLC2   = 2.2486807e-010      WPDIBLC2   = -4.9545282e-010     PPDIBLC2   = -1.2097902e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0105725           WAIGC      = -6.03905e-010       BIGC       = 0.0026243734
+WBIGC      = -6.1456728e-010     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.22429989         LKT1       = -4.0323714e-009
+WKT1       = -1.9206657e-008     PKT1       = 2.1694158e-015      KT1L       = 0
+KT2        = -0.026              UTE        = -1.4688721          LUTE       = 1.6738397e-007
+WUTE       = 3.2359571e-007      PUTE       = -1.5088566e-013     UA1        = 1.3137101e-009
+LUA1       = 2.6527969e-016      WUA1       = 7.5909845e-016      PUA1       = -2.8547373e-022
+UB1        = -1.3046172e-018     LUB1       = -2.8458619e-025     WUB1       = -4.820494e-025
+PUB1       = 1.8220737e-031      UC1        = -2e-010             PRT        = 0
+AT         = 163334.85           LAT        = -0.011669879        WAT        = -0.020237283
+PAT        = 1.1059682e-010      JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.14 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.2070400E-09
+LL         = 4.3827800E-03       WL         = 0                   LLN        = -0.84142000
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.3827800E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.2070400E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11383137+dvthn'  LVTH0      = '9.9521526e-011+dlvthn'
+WVTH0      = '2.3405558e-009+dwvthn'
+PVTH0      = '6.2443166e-016+dpvthn'
+K1         = 0.158               K2         = 0.056962713         LK2        = -1.4113154e-009
+WK2        = -1.9979979e-008     PK2        = 1.5415657e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.12003816         LVOFF      = '-1.9239482e-009+dlvoffn'
+WVOFF      = '-4.7744488e-009+dwvoffn'
+PVOFF      = 6.4394515e-016      NFACTOR    = 2.2247345           LNFACTOR   = -1.5137827e-007
+WNFACTOR   = -1.2542615e-006     PNFACTOR   = 1.2592705e-013      ETA0       = '0.19187436+deta0n'
+LETA0      = -1.6969282e-009     WETA0      = '9.1031244e-010+dweta0n'
+PETA0      = -1.3008993e-016     ETAB       = -0.10368843         LETAB      = 3.3852398e-009
+WETAB      = 1.2744374e-008      PETAB      = -1.821259e-015      U0         = 209.44728
+LU0        = -6.2760779e-007     WU0        = 2.1640506e-005      PU0        = -1.1747511e-012
+UA         = -1.8351848e-009     LUA        = 2.227225e-017       WUA        = 1.1825665e-016
+PUA        = 6.1142267e-024      UB         = 2.3258651e-018      LUB        = -2.4064499e-026
+WUB        = 1.1618212e-025      PUB        = -1.756214e-032      UC         = 2.3571474e-010
+LUC        = -8.4104306e-018     WUC        = -5.5857624e-017     PUC        = 3.2262302e-024
+VSAT       = 104054.84           LVSAT      = '-0.00057946516+dlvsatn'
+WVSAT      = -0.0036412498       PVSAT      = '5.2035972e-010+dpvsatn'
+A0         = 6.1173909           LA0        = -1.7934896e-007     WA0        = -2.638476e-006
+PA0        = 1.2109525e-013      AGS        = -0.027678275        LAGS       = 2.1762256e-009
+WAGS       = 2.0270912e-008      PAGS       = -1.1708094e-015     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.043518637        LKETA      = 3.4270302e-009      WKETA      = 2.2677149e-008
+PKETA      = -1.0927554e-015     DWG        = 0                   DWB        = 0
+PCLM       = 1.4607009           LPCLM      = -6.5996127e-008     WPCLM      = -4.6211671e-007
+PPCLM      = 2.7683137e-014      PDIBLC1    = 0.0001              PDIBLC2    = 0.0085431142
+LPDIBLC2   = -4.3567594e-010     WPDIBLC2   = -2.2523236e-009     PPDIBLC2   = 1.3008993e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0105725           WAIGC      = -6.03905e-010       BIGC       = 0.0026243734
+WBIGC      = -6.1456728e-010     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.27556446         LKT1       = 3.2936886e-009
+WKT1       = -3.8478357e-010     PKT1       = -5.2035972e-016     KT1L       = 0
+KT2        = -0.026              UTE        = 0.28943897          LUTE       = -8.3890813e-008
+WUTE       = -1.3839626e-006     PUTE       = 9.3136206e-014      UA1        = 4.4938185e-009
+LUA1       = -1.8917975e-016     WUA1       = -1.9907739e-015     PUA1       = 1.07502e-022
+UB1        = -4.8534669e-018     LUB1       = 2.2256893e-025      WUB1       = 1.3308372e-024
+PUB1       = -7.6866627e-032     UC1        = -3.4397334e-010     LUC1       = 2.0574783e-017
+WUC1       = 4.096406e-017       PUC1       = -5.8540468e-024     PRT        = 0
+AT         = 126862.83           LAT        = -0.0064577755       WAT        = -0.041768888
+PAT        = 3.1876117e-009      JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.15 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.6064050E-09
+LL         = 5.4893200E-03       WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.4893200E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.6064050E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.055588619+dvthn' LVTH0      = '3.4635122e-009+dlvthn'
+WVTH0      = '1.2205008e-008+dwvthn'
+PVTH0      = '5.4679624e-017+dpvthn'
+K1         = 0.158               K2         = 0.0147865           LK2        = 1.0247025e-009
+WK2        = 6.8047256e-009      PK2        = -5.4679624e-018     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.069902604        LVOFF      = '-4.8196828e-009+dlvoffn'
+WVOFF      = '3.4538893e-008+dwvoffn'
+PVOFF      = -1.6267188e-015     NFACTOR    = -8.5367793          LNFACTOR   = 4.7018632e-007
+WNFACTOR   = 4.7837923e-006      PNFACTOR   = -2.2281947e-013     ETA0       = '0.37361522+deta0n'
+LETA0      = -1.2193935e-008     WETA0      = '-1.2441308e-007+dweta0n'
+PETA0      = 7.1083511e-015      ETAB       = -0.045077778        WETAB      = -1.8788156e-008
+U0         = 421.84527           LU0        = -1.2895312e-005     WU0        = -2.203624e-005
+PU0        = 1.3479347e-012      UA         = -1.8414017e-009     LUA        = 2.2631328e-017
+WUA        = 1.0004103e-015      PUA        = -4.4837291e-023     UB         = 4.1877943e-018
+LUB        = -1.3160599e-025     WUB        = -1.4611938e-024     PUB        = 7.3544094e-032
+UC         = 3.2297167e-010      LUC        = -1.3450225e-017     WUC        = -6.6269037e-017
+PUC        = 3.8275737e-024      VSAT       = 65844.045           LVSAT      = '0.001627518+dlvsatn'
+WVSAT      = 0.01483505          PVSAT      = '-5.4679624e-010+dpvsatn'
+A0         = 5.3648205           LA0        = -1.3588192e-007     WA0        = 1.617617e-006
+PA0        = -1.247286e-013      AGS        = 0.029595394         LAGS       = -1.1317927e-009
+WAGS       = -3.7868021e-006     PAGS       = 2.1871849e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.48323995         LKETA      = 2.8824498e-008      WKETA      = 9.8427684e-008
+PKETA      = -5.4679624e-015     DWG        = 0                   DWB        = 0
+PCLM       = -0.68536984         LPCLM      = 5.7956843e-008      WPCLM      = 4.5265998e-007
+PPCLM      = -2.5152627e-014     PDIBLC1    = 0.0001              PDIBLC2    = 0.0062711611
+LPDIBLC2   = -3.0445225e-010     WPDIBLC2   = -4.7335026e-009     PPDIBLC2   = 2.7339812e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0105725           WAIGC      = -6.03905e-010       BIGC       = 0.0026243734
+WBIGC      = -6.1456728e-010     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = 0.10374656          LKT1       = -1.8614595e-008
+WKT1       = -1.1826464e-007     PKT1       = 6.2881567e-015      KT1L       = 0
+KT2        = -0.026              UTE        = -1.2108674          LUTE       = 2.7640347e-009
+WUTE       = 5.6137717e-007      PUTE       = -1.9222922e-014     UA1        = 2.7461255e-009
+LUA1       = -8.8236323e-017     WUA1       = -7.2982278e-016     PUA1       = 3.4671857e-023
+UB1        = -1e-018             UC1        = 2.3181639e-010      LUC1       = -1.2681738e-017
+WUC1       = -2.7339812e-016     PUC1       = 1.2302915e-023      PRT        = 0
+AT         = -76949.72           LAT        = 0.0053140499        WAT        = 0.047738005
+PAT        = -1.9821364e-009     JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.16 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12528395+dvthn'  WVTH0      = '-2.8427654e-009+dwvthn'
+K1         = 0.158               K2         = 0.03355             K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.1232284          WVOFF      = '6.0408765e-009+dwvoffn'
+NFACTOR    = 0.1542591           WNFACTOR   = 2.0238855e-007      ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 269.05556           WU0        = 3.1981111e-006
+UA         = -1.0630247e-009     WUA        = 1.7767284e-017      UB         = 2.2773457e-018
+WUB        = 3.9088025e-026      UC         = 1.982642e-010       WUC        = -2.3168538e-017
+VSAT       = 100000              A0         = 5.4999751           WA0        = -1.0238682e-007
+AGS        = 0.71069828          LAGS       = 6.3706294e-007      WAGS       = 1.1677258e-008
+PAGS       = 1.9963618e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.0077407407
+WKETA      = -8.1018815e-009     DWG        = 0                   DWB        = 0
+PCLM       = 1.9623457           WPCLM      = -2.4874198e-007     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0010185185        WPDIBLC2   = 1.066037e-009       PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.2                 PDITSD     = 0.5                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.93
+BETA0      = 11.6                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0096888993
+LAIGC      = -2.0564961e-010     WAIGC      = -3.7752748e-011     PAIGC      = 1.9963618e-017
+BIGC       = 0.0014768074        WBIGC      = 2.8232214e-012      CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.26660494
+WKT1       = 3.5534568e-009      KT1L       = 0                   KT2        = -0.026
+UTE        = -1.8743557          WUTE       = 6.6065158e-008      UA1        = 1.0941609e-009
+WUA1       = 2.1876537e-016      UB1        = -4.0697267e-018     WUB1       = 6.5692152e-025
+UC1        = -1.5310494e-010     WUC1       = -2.5229543e-017     PRT        = 0
+AT         = 191697.53           WAT        = 0.0017767284        JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn'          PVTH0      = '0+dpvthn'
+LVOFF      = '0+dlvoffn'         WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'
+PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.17 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12725699+dvthn'  LVTH0      = '-1.9708813e-009+dlvthn'
+WVTH0      = '-4.550734e-009+dwvthn'
+PVTH0      = '1.7061016e-015+dpvthn'
+K1         = 0.158               K2         = 0.030305613         LK2        = 3.2408402e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 35                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.13797797         LVOFF      = '1.4733449e-008+dlvoffn'
+WVOFF      = '1.0097302e-008+dwvoffn'
+PVOFF      = -4.0519912e-015     NFACTOR    = 0.004389702         LNFACTOR   = 1.4970557e-007
+WNFACTOR   = 1.9588845e-007      PNFACTOR   = 6.4929961e-015      ETA0       = '0.18+deta0n'
+ETAB       = -0.08               U0         = 281.04014           LU0        = -1.1971481e-005
+WU0        = 5.0483685e-007      PU0        = 2.6903302e-012      UA         = -9.0342314e-010
+LUA        = -1.5942709e-016     WUA        = 1.6128904e-018      PUA        = 1.6136735e-023
+UB         = 2.3287666e-018      LUB        = -5.1364724e-026     WUB        = 2.9369684e-026
+PUB        = 9.7077179e-033      UC         = 2.3191562e-010      LUC        = -3.3614641e-017
+WUC        = -4.1273005e-017     PUC        = 1.8084677e-023      VSAT       = 100000
+A0         = 6.7722325           LA0        = -1.2708667e-006     WA0        = -3.123807e-007
+PA0        = 2.0976434e-013      AGS        = 1.0943833           LAGS       = 2.5379729e-007
+WAGS       = 1.0778963e-008      PAGS       = 2.086093e-014       A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.0027250703       LKETA      = -5.0101878e-009     WKETA      = -9.8952485e-009
+PKETA      = 1.7914066e-015      DWG        = 0                   DWB        = 0
+PCLM       = 2.7704383           LPCLM      = -8.0720927e-007     WPCLM      = -4.2167379e-007
+PPCLM      = 1.7274278e-013      PDIBLC1    = 0.0001              PDIBLC2    = 0.0012169349
+LPDIBLC2   = -1.9819953e-010     WPDIBLC2   = 9.59289e-010        PPDIBLC2   = 1.0663135e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094830247        WAIGC      = -1.7767284e-011     BIGC       = 0.0014768074
+WBIGC      = 2.8232214e-012      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.27493843         LKT1       = 8.3243803e-009
+WKT1       = 8.0368742e-009      PKT1       = -4.4785166e-015     KT1L       = 0
+KT2        = -0.026              UTE        = -2.1568746          LUTE       = 2.8221008e-007
+WUTE       = 2.9754387e-008      PUTE       = 3.627108e-014       UA1        = 8.9276903e-010
+LUA1       = 2.0117175e-016      WUA1       = 1.6028026e-016      PUA1       = 5.8421183e-023
+UB1        = -5.4554472e-018     LUB1       = 1.3842057e-024      WUB1       = 1.1463265e-024
+PUB1       = -4.8886997e-031     UC1        = -1.2492981e-010     LUC1       = -2.8144334e-017
+WUC1       = -4.0387764e-017     PUC1       = 1.5141651e-023      PRT        = 0
+AT         = 251639.09           LAT        = -0.059876042        WAT        = 0.0018066178
+PAT        = -2.9856777e-011     JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+WETA0      = '0+dweta0n'         LVSAT      = '0+dlvsatn'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.18 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11769956+dvthn'  LVTH0      = '1.6122643e-009+dlvthn'
+WVTH0      = '6.5665538e-010+dwvthn'
+PVTH0      = '-2.4618463e-016+dpvthn'
+K1         = 0.158               K2         = 0.04590732          LK2        = -2.6083471e-009
+WK2        = -7.770422e-010      PK2        = 2.9131848e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.071633015        LVOFF      = '-1.0139731e-008+dlvoffn'
+WVOFF      = '-3.9939683e-009+dwvoffn'
+PVOFF      = 1.2309232e-015      NFACTOR    = 0.39743746          LNFACTOR   = 2.3492587e-009
+WNFACTOR   = 3.2527659e-007      PNFACTOR   = -4.2015511e-014     ETA0       = '0.17389725+deta0n'
+LETA0      = 2.2879613e-009      WETA0      = '3.2832769e-009+dweta0n'
+PETA0      = -1.2309232e-015     ETAB       = -0.08               U0         = 265.98648
+LU0        = -6.327763e-006      WU0        = 9.6639754e-006      PU0        = -7.43494e-013
+UA         = -1.2367732e-009     LUA        = -3.4451844e-017     WUA        = 3.9733457e-017
+PUA        = 1.8450718e-024      UB         = 2.2527043e-018      LUB        = -2.2848422e-026
+WUB        = 7.201245e-026       PUB        = -6.2793494e-033     UC         = 1.5916444e-010
+LUC        = -6.3397197e-018     WUC        = 1.1189258e-017      PUC        = -1.5837878e-024
+VSAT       = 100000              A0         = 4.2435329           LA0        = -3.2283981e-007
+WA0        = 5.488975e-007       PA0        = -1.131348e-013      AGS        = 4.105322
+LAGS       = -8.7502438e-007     WAGS       = -5.6464097e-007     PAGS       = 2.3658983e-013
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.043867216        LKETA      = 1.0414287e-008
+WKETA      = -1.4397076e-009     PKETA      = -1.3786339e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.73031301          LPCLM      = -4.235223e-008
+WPCLM      = 4.1276876e-008      PPCLM      = -8.2061544e-016     PDIBLC1    = 0.0001
+PDIBLC2    = 7.7997088e-005      LPDIBLC2   = 2.2879613e-010      WPDIBLC2   = 1.5720376e-009
+PPDIBLC2   = -1.2309232e-016     PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.2
+PDITSD     = 0.5                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.93                BETA0      = 11.6
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0094830247        WAIGC      = -1.7767284e-011
+BIGC       = 0.0014768074        WBIGC      = 2.8232214e-012      CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.23849483
+LKT1       = -5.3385763e-009     WKT1       = -1.1569782e-008     PKT1       = 2.8721541e-015
+KT1L       = 0                   KT2        = -0.026              UTE        = -0.90937706
+LUTE       = -1.8548535e-007     WUTE       = 2.2587388e-008      PUTE       = 3.8958037e-014
+UA1        = 2.0675987e-009      LUA1       = -2.3927999e-016     WUA1       = 3.5350638e-016
+PUA1       = -1.4020625e-023     UB1        = -1.5463838e-018     LUB1       = -8.13291e-026
+WUB1       = -3.5197894e-025     PUB1       = 7.285506e-032       UC1        = -2e-010
+PRT        = 0                   AT         = 119515.95           LAT        = -0.010342162
+WAT        = 0.0033372872        PAT        = -6.0371529e-010     JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVSAT      = '0+dlvsatn'         PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.19 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.2070400E-09
+LL         = 4.3827800E-03       WL         = 0                   LLN        = -0.84142000
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.3827800E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.2070400E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11922247+dvthn'  LVTH0      = '1.3946298e-009+dlvthn'
+WVTH0      = '-5.5985737e-010+dwvthn'
+PVTH0      = '-7.2336568e-017+dpvthn'
+K1         = 0.158               K2         = 0.015889961         LK2        = 1.6813405e-009
+WK2        = 2.1171618e-009      PK2        = -1.2228325e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.14045599         LVOFF      = '-3.0445258e-010+dlvoffn'
+WVOFF      = '6.2103442e-009+dwvoffn'
+PVOFF      = -2.273435e-016      NFACTOR    = -0.35693319         LNFACTOR   = 1.1015403e-007
+WNFACTOR   = 1.346757e-007       PNFACTOR   = -1.4777327e-014     ETA0       = '0.17883237+deta0n'
+LETA0      = 1.5826986e-009      WETA0      = '7.9269015e-009+dweta0n'
+PETA0      = -1.8945292e-015     ETAB       = -0.08               U0         = 226.34537
+LU0        = -6.6277417e-007     WU0        = 1.2549333e-005      PU0        = -1.1558316e-012
+UA         = -1.8768257e-009     LUA        = 5.7016075e-017      WUA        = 1.4065947e-016
+PUA        = -1.2577951e-023     UB         = 2.6155332e-018      LUB        = -7.4699187e-026
+WUB        = -3.9659352e-026     PUB        = 9.6793217e-033      UC         = 1.4504318e-010
+LUC        = -4.3216947e-018     WUC        = -7.0763269e-018     PUC        = 1.0264903e-024
+VSAT       = 99437.246           LVSAT      = '8.0421435e-005+dlvsatn'
+WVSAT      = -0.0011569821       PVSAT      = '1.6534073e-010+dpvsatn'
+A0         = 1.9682554           LA0        = 2.3130407e-009      WA0        = -4.0624112e-007
+PA0        = 2.3361095e-014      AGS        = -3.3931556          LAGS       = 1.965598e-007
+WAGS       = 1.8308977e-006      PAGS       = -1.0574917e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.01655145          LKETA      = 1.7800423e-009      WKETA      = -9.6405576e-009
+PKETA      = -2.0667591e-016     DWG        = 0                   DWB        = 0
+PCLM       = 0.51329726          LPCLM      = -1.1339183e-008     WPCLM      = 4.7586465e-008
+PPCLM      = -1.7222992e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.0021395997
+LPDIBLC2   = -6.5821115e-011     WPDIBLC2   = 1.1927672e-009      PPDIBLC2   = -6.8891969e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094830247        WAIGC      = -1.7767284e-011     BIGC       = 0.0014768074
+WBIGC      = 2.8232214e-012      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.29257955         LKT1       = 2.3905032e-009
+WKT1       = 8.7693342e-009      PKT1       = -3.4445985e-017     KT1L       = 0
+KT2        = -0.026              UTE        = -3.2710829          LUTE       = 1.520187e-007
+WUTE       = 5.3159815e-007      PUTE       = -3.3783113e-014     UA1        = -1.2906386e-012
+LUA1       = 5.6378566e-017      WUA1       = 4.2759484e-016      PUA1       = -2.4608377e-023
+UB1        = -2.8958929e-018     LUB1       = 1.1152506e-025      WUB1       = 2.7766237e-025
+PUB1       = -1.7125028e-032     UC1        = -2.6783196e-010     LUC1       = 9.6936551e-018
+PRT        = 0                   AT         = 53453.871           LAT        = -0.00090143533
+WAT        = -0.0022748701       PAT        = 1.9830071e-010      JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.20 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.6064050E-09
+LL         = 5.4893200E-03       WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.4893200E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.6064050E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.10167823+dvthn'  LVTH0      = '2.4079519e-009+dlvthn'
+WVTH0      = '-1.2591202e-008+dwvthn'
+PVTH0      = '6.2257102e-016+dpvthn'
+K1         = 0.158               K2         = 0.038477346         LK2        = 3.7673608e-010
+WK2        = -5.9409499e-009     PK2        = 3.4313798e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.022045386        LVOFF      = '-7.1436243e-009+dlvoffn'
+WVOFF      = '8.7917102e-009+dwvoffn'
+PVOFF      = -3.7643829e-016     NFACTOR    = 1.141708            LNFACTOR   = 2.3595364e-008
+WNFACTOR   = -4.2323383e-007     PNFACTOR   = 1.7446467e-014      ETA0       = '0.31673082+deta0n'
+LETA0      = -6.3820535e-009     WETA0      = '-9.3809271e-008+dweta0n'
+PETA0      = 3.9815588e-015      ETAB       = -0.059032928        LETAB      = -1.2110182e-009
+WETAB      = -1.1280285e-008     PETAB      = 6.5152781e-016      U0         = 536.86624
+LU0        = -1.859787e-005      WU0        = -8.3917522e-005     PU0        = 4.4159107e-012
+UA         = 1.1422171e-009      LUA        = -1.173581e-016      WUA        = -6.0477666e-016
+PUA        = 3.0477023e-023      UB         = 1.4856478e-018      LUB        = -9.4391515e-027
+WUB        = -7.4389717e-027     PUB        = 7.8183337e-033      UC         = 4.273256e-010
+LUC        = -2.0625791e-017     WUC        = -1.2241145e-016     PUC        = 7.6880282e-024
+VSAT       = 114010.8            LVSAT      = '-0.00076131925+dlvsatn'
+WVSAT      = -0.011078663        PVSAT      = '7.3839819e-010+dpvsatn'
+A0         = 8.3864945           LA0        = -3.6839225e-007     WA0        = -8.0435532e-009
+PA0        = 3.6195989e-016      AGS        = -11.645123          LAGS       = 6.7317775e-007
+WAGS       = 2.4941963e-006      PAGS       = -1.4406004e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.18765679         LKETA      = 1.3574722e-008      WKETA      = -6.0596055e-008
+PKETA      = 2.7364168e-015      DWG        = 0                   DWB        = 0
+PCLM       = -0.30800891         LPCLM      = 3.6097901e-008      WPCLM      = 2.496398e-007
+PPCLM      = -1.3392516e-014     PDIBLC1    = 0.0001              PDIBLC2    = -0.0036920083
+LPDIBLC2   = 2.7100148e-010      WPDIBLC2   = 6.2668248e-010      PPDIBLC2   = -3.6195989e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094830247        WAIGC      = -1.7767284e-011     BIGC       = 0.0014768074
+WBIGC      = 2.8232214e-012      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.2547403          LKT1       = 2.0498024e-010
+WKT1       = 7.4601294e-008      PKT1       = -3.8367749e-015     KT1L       = 0
+KT2        = -0.035318699        LKT2       = 5.3823033e-010      WKT2       = 5.0134599e-009
+PKT2       = -2.8956792e-016     UTE        = -1.1259554          LUTE       = 2.8120214e-008
+WUTE       = 5.1569447e-007      PUTE       = -3.2864547e-014     UA1        = -4.7562125e-010
+LUA1       = 8.3775001e-017      WUA1       = 1.003477e-015       PUA1       = -5.7870235e-023
+UB1        = -8.4152107e-019     LUB1       = -7.1315518e-027     WUB1       = -8.5261664e-026
+PUB1       = 3.8367749e-033      UC1        = -2.7635855e-010     LUC1       = 1.0186135e-017
+PRT        = 0                   AT         = 30410.12            LAT        = 0.00042952792
+WAT        = -0.010021589        PAT        = 6.4573645e-010      JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.21 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12377778+dvthn'  WVTH0      = '-2.5204444e-009+dwvthn'
+K1         = 0.158               K2         = 0.041941667         WK2        = -1.7958167e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 35                  DVT1       = 1.8                 DVT2       = 0.08
+DVT0W      = -2e-006             DVT1W      = 10000               DVT2W      = 0
+DSUB       = 0.5                 MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 9e-008
+LPEB       = 4e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12051852         WVOFF      = '5.460963e-009+dwvoffn'
+NFACTOR    = 1.1902963           WNFACTOR   = -1.9323407e-008     ETA0       = '0.21925926+deta0n'
+WETA0      = '-8.4014815e-009+dweta0n'
+ETAB       = -0.08               U0         = 215.2963            WU0        = 1.4702593e-005
+UA         = -1.7848148e-009     WUA        = 1.7223037e-016      UB         = 2.9114815e-018
+WUB        = -9.6617037e-026     UC         = 1.6851852e-010      WUC        = -1.6802963e-017
+VSAT       = 80370.37            WVSAT      = 0.0042007407        A0         = 6.0241467
+WA0        = -2.1455955e-007     AGS        = 0.55319656          LAGS       = 8.4063178e-007
+WAGS       = 4.5382625e-008      PAGS       = -2.3600113e-014     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.02597037         WKETA      = -4.2007407e-009     DWG        = 0
+DWB        = 0                   PCLM       = 0.3387037           WPCLM      = 9.8717407e-008
+PDIBLC1    = 0.0001              PDIBLC2    = 0.0045277778        WPDIBLC2   = 3.1505556e-010
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0096719603        LAIGC      = -2.2264258e-010     WAIGC      = -3.412779e-011
+PAIGC      = 2.3600113e-017      BIGC       = 0.001382037         WBIGC      = 2.3104074e-011
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon'              CGDO       = 'cgon'
+CGBO       = 0                   CGDL       = 'cgln'              CGSL       = 'cgln'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.053
+KT1        = -0.33833333         WKT1       = 1.8903333e-008      KT1L       = 0
+KT2        = -0.026              UTE        = -2.5133978          WUTE       = 2.0282016e-007
+UA1        = -3.2374596e-010     WUA1       = 5.2219744e-016      UB1        = 8.9033333e-019
+WUB1       = -4.0453133e-025     UC1        = -4.8790741e-010     WUC1       = 4.6418185e-017
+PRT        = 0                   AT         = 171743.15           WAT        = 0.0060469663
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 4.5E-13
+JSWD       = 4.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn'               CJD        = 'cjn'               MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn'             CJSWD      = 'cjswn'             MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.5                 PBSWGD     = 0.5
+CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'            MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.14E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03
+TCJSWG     = 8.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthn'
+PVTH0      = '0+dpvthn'          LVOFF      = '0+dlvoffn'         LVSAT      = '0+dlvsatn'
+PVSAT      = '0+dpvsatn'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.22 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12484589+dvthn'  LVTH0      = '-1.0669433e-009+dlvthn'
+WVTH0      = '-4.0347586e-009+dwvthn'
+PVTH0      = '1.5126588e-015+dpvthn'
+K1         = 0.158               K2         = 0.038461406         LK2        = 3.4764568e-009
+WK2        = -1.7453395e-009     PK2        = -5.0421961e-017     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.1304653          LVOFF      = '9.9359092e-009+dlvoffn'
+WVOFF      = '8.4895912e-009+dwvoffn'
+PVOFF      = -3.0253177e-015     NFACTOR    = 0.91865124          LNFACTOR   = 2.7134813e-007
+WNFACTOR   = 2.3648336e-010      PNFACTOR   = -1.953851e-014      ETA0       = '0.21925926+deta0n'
+WETA0      = '-8.4014815e-009+dweta0n'
+ETAB       = -0.08               U0         = 173.63481           LU0        = 4.1615947e-005
+WU0        = 2.3489577e-005      PU0        = -8.7773793e-012     UA         = -2.1649026e-009
+LUA        = 3.7967235e-016      WUA        = 2.715695e-016       PUA        = -9.9230545e-023
+UB         = 3.3497296e-018      LUB        = -4.3776905e-025     WUB        = -1.8911639e-025
+PUB        = 9.2398243e-032      UC         = 1.5318668e-010      LUC        = 1.5315082e-017
+WUC        = -2.4425011e-017     PUC        = 7.6137161e-024      VSAT       = 89215.663
+LVSAT      = '-0.008835624+dlvsatn'
+WVSAT      = 0.0023078481        PVSAT      = '1.8908235e-009+dpvsatn'
+A0         = 6.0405116           LA0        = -1.6347005e-008     WA0        = -1.5579243e-007
+PA0        = -5.8702886e-014     AGS        = 1.5234958           LAGS       = -1.2860685e-007
+WAGS       = -8.1051109e-008     PAGS       = 1.0269542e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.017541196        LKETA      = -8.4199607e-009     WKETA      = -6.7245976e-009
+PKETA      = 2.521098e-015       DWG        = 0                   DWB        = 0
+PCLM       = 0.37408487          LPCLM      = -3.5342496e-008     WPCLM      = 9.1145837e-008
+PPCLM      = 7.5632941e-015      PDIBLC1    = 0.0001              PDIBLC2    = 0.0041389187
+LPDIBLC2   = 3.8843404e-010      WPDIBLC2   = 3.3398448e-010      PPDIBLC2   = -1.8908235e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094490741        WAIGC      = -1.0501852e-011     BIGC       = 0.001382037
+WBIGC      = 2.3104074e-011      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.3546109          LKT1       = 1.6259771e-008
+WKT1       = 2.5086783e-008      PKT1       = -6.1766902e-015     KT1L       = 0
+KT2        = -0.026              UTE        = -3.6234707          LUTE       = 1.1088595e-006
+WUTE       = 3.4360595e-007      PUTE       = -1.4063189e-013     UA1        = -2.8584543e-009
+LUA1       = 2.5319376e-015      WUA1       = 9.6304205e-016      PUA1       = -4.4036272e-022
+UB1        = 3.8118167e-018      LUB1       = -2.9182899e-024     WUB1       = -8.3686802e-025
+PUB1       = 4.318641e-031       UC1        = -5.9307182e-010     LUC1       = 1.0504946e-016
+WUC1       = 5.9794627e-017      PUC1       = -1.336182e-023      PRT        = 0
+AT         = 273815.94           LAT        = -0.10196121         WAT        = -0.0029392261
+PAT        = 8.9763696e-009      JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.23 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11562919+dvthn'  LVTH0      = '2.3884605e-009+dlvthn'
+WVTH0      = '1.0997147e-009+dwvthn'
+PVTH0      = '-4.1229062e-016+dpvthn'
+K1         = 0.158               K2         = 0.047070372         LK2        = 2.4889597e-010
+WK2        = -1.0259354e-009     PK2        = -3.2013154e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.088027384        LVOFF      = '-5.9743587e-009+dlvoffn'
+WVOFF      = '-4.8557331e-010+dwvoffn'
+PVOFF      = 3.3953345e-016      NFACTOR    = 2.1217595           LNFACTOR   = -1.7970546e-007
+WNFACTOR   = -4.3728322e-008     PNFACTOR   = -3.0558011e-015     ETA0       = '0.23756749+deta0n'
+LETA0      = -6.8638838e-009     WETA0      = '-1.0342154e-008+dweta0n'
+PETA0      = 7.2757168e-016      ETAB       = -0.08               U0         = 343.46187
+LU0        = -2.2053389e-005     WU0        = -6.9157566e-006     PU0        = 2.62179e-012
+UA         = -7.0546032e-010     LUA        = -1.6748264e-016     WUA        = -7.3967504e-017
+PUA        = 3.0313663e-023      UB         = 2.4198117e-018      LUB        = -8.9136405e-026
+WUB        = 3.6251465e-026      PUB        = 7.906279e-033       UC         = 2.4253732e-010
+LUC        = -1.8183091e-017     WUC        = -6.6525386e-018     PUC        = 9.5069367e-025
+VSAT       = 59602.438           LVSAT      = '0.0022665785+dlvsatn'
+WVSAT      = 0.0086450783        PVSAT      = '-4.8504779e-010+dpvsatn'
+A0         = 10.808097           LA0        = -1.8037477e-006     WA0        = -8.5591925e-007
+PA0        = 2.0377949e-013      AGS        = 0.92933154          LAGS       = 9.414944e-008
+WAGS       = 1.1502099e-007      PAGS       = 2.9186635e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.073084864        LKETA      = 1.2403744e-008      WKETA      = 4.812869e-009
+PKETA      = -1.8043778e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.28209621          LPCLM      = -8.5531263e-010     WPCLM      = 1.3719527e-007
+PPCLM      = -9.7009558e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.0052827962
+LPDIBLC2   = -4.0413522e-011     WPDIBLC2   = 4.5821057e-010      PPDIBLC2   = -6.5481452e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094490741        WAIGC      = -1.0501852e-011     BIGC       = 0.001382037
+WBIGC      = 2.3104074e-011      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = -0.34428682         LKT1       = 1.2389203e-008
+WKT1       = 1.1069704e-008      PKT1       = -9.215908e-016      KT1L       = 0
+KT2        = -0.026              UTE        = -0.22138209         LUTE       = -1.6660701e-007
+WUTE       = -1.2464354e-007     PUTE       = 3.4918071e-014      UA1        = 6.7661086e-009
+LUA1       = -1.0763774e-015     WUA1       = -6.5197475e-016     PUA1       = 1.6511822e-022
+UB1        = -6.0436206e-018     LUB1       = 7.7658154e-025      WUB1       = 6.1042973e-025
+PUB1       = -1.1073782e-031     UC1        = -3.8239604e-010     LUC1       = 2.6065652e-017
+WUC1       = 3.9032752e-017      PUC1       = -5.5780496e-024     PRT        = 0
+AT         = -16182.591          LAT        = 0.0067612372        WAT        = 0.032376774
+PAT        = -4.2638427e-009     JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 4.5E-13             JSWD       = 4.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn'               CJD        = 'cjn'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn'             CJSWD      = 'cjswn'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.5
+PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.14E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.24 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.2070400E-09
+LL         = 4.3827800E-03       WL         = 0                   LLN        = -0.84142000
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.3827800E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.2070400E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11323157+dvthn'  LVTH0      = '2.7310976e-009+dlvthn'
+WVTH0      = '7.2219659e-010+dwvthn'
+PVTH0      = '-3.5834068e-016+dpvthn'
+K1         = 0.158               K2         = 0.032756589         LK2        = 2.2944343e-009
+WK2        = -1.4922965e-009     PK2        = -2.5348531e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.12619427         LVOFF      = '-5.2004665e-010+dlvoffn'
+WVOFF      = '3.1583363e-009+dwvoffn'
+PVOFF      = -1.8120637e-016     NFACTOR    = 0.66053727          LNFACTOR   = 2.9113278e-008
+WNFACTOR   = -8.3062984e-008     PNFACTOR   = 2.5653935e-015      ETA0       = '0.2484001+deta0n'
+LETA0      = -8.4119385e-009     WETA0      = '-6.9605928e-009+dweta0n'
+PETA0      = 2.4432319e-016      ETAB       = -0.053369675        LETAB      = -3.8056572e-009
+WETAB      = -5.6988896e-009     PETAB      = 8.1441064e-016      U0         = 199.93675
+LU0        = -1.5426594e-006     WU0        = 1.8200778e-005      PU0        = -9.6753613e-013
+UA         = -1.9620944e-009     LUA        = 1.2099035e-017      WUA        = 1.5890696e-016
+PUA        = -2.9657049e-024     UB         = 1.9270526e-018      LUB        = -1.871773e-026
+WUB        = 1.0767551e-025      PUB        = -2.3007101e-033     UC         = 8.8541548e-011
+LUC        = 3.8239674e-018      WUC        = 5.0150228e-018      PUC        = -7.1668136e-025
+VSAT       = 76950.241           LVSAT      = '-0.00021254236+dlvsatn'
+WVSAT      = 0.0036552368        PVSAT      = '2.2803498e-010+dpvsatn'
+A0         = -4.7335549          LA0        = 4.1726159e-007      WA0        = 1.0279463e-006
+PA0        = -6.5437895e-014     AGS        = 3.5454268           LAGS       = -2.7970862e-007
+WAGS       = 3.4604108e-007      PAGS       = -3.82773e-015       A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.052505842         LKETA      = -5.5440347e-009     WKETA      = -1.7334798e-008
+PKETA      = 1.3606766e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.19207485          LPCLM      = 1.2009362e-008      WPCLM      = 1.1632806e-007
+PPCLM      = -6.7188878e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.0077132784
+LPDIBLC2   = -3.8774621e-010     PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.2
+PDITSD     = 0.5                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.93                BETA0      = 11.6
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0094490741        WAIGC      = -1.0501852e-011
+BIGC       = 0.001382037         WBIGC      = 2.3104074e-011      CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon'              CGDO       = 'cgon'              CGBO       = 0
+CGDL       = 'cgln'              CGSL       = 'cgln'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.053              KT1        = -0.2658706
+LKT1       = 1.182985e-009       WKT1       = 3.0536202e-009      PKT1       = 2.2396293e-016
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.4955044
+LUTE       = 1.5473865e-008      WUTE       = 1.5162436e-007      PUTE       = -4.5625178e-015
+UA1        = -1.6725987e-009     LUA1       = 1.2957209e-016      WUA1       = 7.8525477e-016
+PUA1       = -4.0271792e-023     UB1        = -3.6582401e-019     LUB1       = -3.4814768e-026
+WUB1       = -2.6377237e-025     PUB1       = 1.4191696e-032      UC1        = -2.6783196e-010
+LUC1       = 9.6936551e-018      PRT        = 0                   AT         = 12741.826
+LAT        = 0.0026277383        WAT        = 0.0064375075        PAT        = -5.5694245e-010
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 4.5E-13
+JSWD       = 4.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn'               CJD        = 'cjn'               MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn'             CJSWD      = 'cjswn'             MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.5                 PBSWGD     = 0.5
+CJSWGS     = 'cjswgn'            CJSWGD     = 'cjswgn'            MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.14E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03
+TCJSWG     = 8.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch.25 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn'              TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.6064050E-09
+LL         = 5.4893200E-03       WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.4893200E-03       WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.6064050E-09+ddlcn'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.0082212622+dvthn'
+LVTH0      = '8.7962932e-009+dlvthn'
+WVTH0      = '7.4085891e-009+dwvthn'
+PVTH0      = '-7.4453401e-016+dpvthn'
+K1         = 0.158               K2         = 0.10148005          LK2        = -1.6749024e-009
+WK2        = -1.9423529e-008     PK2        = 7.821886e-016       K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 35
+DVT1       = 1.8                 DVT2       = 0.08                DVT0W      = -2e-006
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 0.5
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 9e-008              LPEB       = 4e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = 0.087830098         LVOFF      = '-1.2881688e-008+dlvoffn'
+WVOFF      = '-1.4721643e-008+dwvoffn'
+PVOFF      = 8.5150729e-016      NFACTOR    = -0.88390993         LNFACTOR   = 1.1831761e-007
+WNFACTOR   = 1.0248397e-008      PNFACTOR   = -2.8240945e-015     ETA0       = '-0.24734512+deta0n'
+LETA0      = 2.0221364e-008      WETA0      = '2.690298e-008+dweta0n'
+PETA0      = -1.7115724e-015     ETAB       = -0.38987165         LETAB      = 1.5630058e-008
+WETAB      = 5.9519203e-008      PETAB      = -2.9524625e-015     U0         = -46.560696
+LU0        = 1.2694565e-005      WU0        = 4.0935843e-005      PU0        = -2.2806703e-012
+UA         = -4.1981415e-009     LUA        = 1.4124887e-016      WUA        = 5.3806008e-016
+PUA        = -2.4864869e-023     UB         = -3.0972496e-019     LUB        = 1.1047429e-025
+WUB        = 3.767708e-025       PUB        = -1.7843143e-032     UC         = -3.3550902e-010
+LUC        = 2.8316323e-017      WUC        = 4.0835155e-017      PUC        = -2.7855841e-024
+VSAT       = 33289.234           LVSAT      = '0.0023092345+dlvsatn'
+WVSAT      = 0.0061957513        PVSAT      = '8.1299691e-011+dpvsatn'
+A0         = 31.341693           LA0        = -1.6663762e-006     WA0        = -4.920456e-006
+PA0        = 2.7813052e-013      AGS        = 0.98056594          LAGS       = -1.3156713e-007
+WAGS       = -2.0770111e-007     PAGS       = 2.8155367e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.82749237         LKETA      = 4.528299e-008       WKETA      = 7.6328759e-008
+PKETA      = -4.0491525e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.78929517          LPCLM      = -2.2484949e-008     WPCLM      = 1.4816731e-008
+PPCLM      = -8.5578622e-016     PDIBLC1    = 0.0001              PDIBLC2    = -0.00041740019
+LPDIBLC2   = 8.1866342e-011      WPDIBLC2   = -7.4083654e-011     PPDIBLC2   = 4.2789311e-018
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.2                 PDITSD     = 0.5
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.93                BETA0      = 11.6                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0094490741        WAIGC      = -1.0501852e-011     BIGC       = 0.001382037
+WBIGC      = 2.3104074e-011      CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon'
+CGDO       = 'cgon'              CGBO       = 0                   CGDL       = 'cgln'
+CGSL       = 'cgln'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.053              KT1        = 0.13763575          LKT1       = -2.2122775e-008
+WKT1       = -9.3671817e-009     PKT1       = 9.4136484e-016      KT1L       = 0
+KT2        = 0.0019560959        LKT2       = -1.614691e-009      WKT2       = -2.9633462e-009
+PKT2       = 1.7115724e-016      UTE        = 2.6587452           LUTE       = -2.244677e-007
+WUTE       = -2.9423145e-007     PUTE       = 2.1189267e-014      UA1        = 6.3508297e-009
+LUA1       = -3.3384589e-016     WUA1       = -4.5738353e-016     PUA1       = 3.1500635e-023
+UB1        = -8.578133e-019      LUB1       = -6.3984016e-027     WUB1       = -8.1775128e-026
+PUB1       = 3.6798807e-033      UC1        = -2.7635855e-010     LUC1       = 1.0186135e-017
+PRT        = 0                   AT         = -60016.878          LAT        = 0.0068301428
+WAT        = 0.0093297891        PAT        = -7.2399514e-010     JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 4.5E-13             JSWD       = 4.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn'
+CJD        = 'cjn'               MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn'
+CJSWD      = 'cjswn'             MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.5                 PBSWGD     = 0.5                 CJSWGS     = 'cjswgn'
+CJSWGD     = 'cjswgn'            MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.14E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 2.00E-03            TCJSWG     = 8.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

**********************************************************************************************
*                                                                                            *
*                               1.05V STD-VT PMOS DEVICE MODELS                                *
*                                                                                            *
**********************************************************************************************
.MODEL pch.1 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.025
+K3         = -3.2                K3B        = -0.649              W0         = 5e-008
+DVT0       = 28                  DVT1       = 2.23                DVT2       = 0.19
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.093+dvoffp'     NFACTOR    = 0.75
+ETA0       = 0.5                 ETAB       = -0.14               U0         = '50.030356+du0p'
+LU0        = '-3.1824613e-009+dlu0p'
+UA         = -1.6340479e-009     LUA        = 4.2845151e-019      UB         = 2.9260035e-018
+LUB        = -3.148725e-029      UC         = -5e-011             VSAT       = 160000
+A0         = 10.469765           LA0        = 2.1028985e-009      AGS        = 0.6694838
+LAGS       = 1.1669332e-006      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.1344
+DWG        = 0                   DWB        = 0                   PCLM       = 0.2
+PDIBLC1    = 0                   PDIBLC2    = 0.0002              PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055276706
+LAIGC      = -2.4739982e-010     BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014
+CIGC       = 1e-010              AIGSD      = 0.00419             BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9000478           LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.25               KT1L       = 0
+KT2        = -0.03875            UTE        = -0.8151333          UA1        = 2.852435e-009
+UB1        = -3.622352e-018      UC1        = -1.171514e-010      PRT        = 0
+AT         = 200000              JSS        = 1.5E-07             JSD        = 1.5E-07
+JSWS       = 7.00E-13            JSWD       = 7.00E-13            JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp'               CJD        = 'cjp'
+MJS        = 0.35                MJD        = 0.35                PBSWS      = 0.4
+PBSWD      = 0.4                 CJSWS      = 'cjswp'             CJSWD      = 'cjswp'
+MJSWS      = 0.06                MJSWD      = 0.06                PBSWGS     = 0.35
+PBSWGD     = 0.35                CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'
+MJSWGS     = 0.9                 MJSWGD     = 0.9                 TPB        = 1.9E-03
+TCJ        = 9.39E-04            TPBSW      = 1.6E-03             TCJSW      = 6.0E-04
+TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03             XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthp'          WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'
+LK2        = '0+dlk2p'           LVSAT      = '0+dlvsatp'         PVSAT      = '0+dpvsatp'
+LVOFF      = '0+dlvoffp'         PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'
+WETA0      = '0+dweta0p'         PETA0      = '0+dpeta0p'         LKT1       = '0+dlkt1p'
+PKT1       = '0+dpkt1p'          LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.2 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.032209748
+LK2        = '-7.2018671e-009+dlk2p'
+K3         = -3.2                K3B        = -0.649              W0         = 5e-008
+DVT0       = 28                  DVT1       = 2.23                DVT2       = 0.19
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.091798375+dvoffp'
+LVOFF      = '-1.2003112e-009+dlvoffp'
+NFACTOR    = 0.53971568          LNFACTOR   = 2.1005446e-007      ETA0       = 0.5
+ETAB       = -0.14               U0         = '46.501345+du0p'    LU0        = '3.5219711e-006+dlu0p'
+UA         = -1.8568682e-009     LUA        = 2.2300521e-016      UB         = 3.0489961e-018
+LUB        = -1.2288966e-025     UC         = -8.9052802e-011     LUC        = 3.9010113e-017
+VSAT       = 156995.94           LVSAT      = '0.003000778+dlvsatp'
+A0         = 10.974755           LA0        = -5.0233563e-007     AGS        = 0.98638677
+LAGS       = 8.5037666e-007      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.1344
+DWG        = 0                   DWB        = 0                   PCLM       = 0.2
+PDIBLC1    = 0                   PDIBLC2    = -0.0011818684       LPDIBLC2   = 1.3803579e-009
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0053160487        LAIGC      = -3.6009336e-011     BIGC       = 0.00099264429
+LBIGC      = 2.0885415e-014      CIGC       = 1e-010              AIGSD      = 0.00419
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.24399188
+LKT1       = '-6.0015559e-009+dlkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.8151333
+UA1        = 2.852435e-009       UB1        = -3.622352e-018      UC1        = -1.171514e-010
+PRT        = 0                   AT         = 200000              JSS        = 1.5E-07
+JSD        = 1.5E-07             JSWS       = 7.00E-13            JSWD       = 7.00E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp'
+CJD        = 'cjp'               MJS        = 0.35                MJD        = 0.35
+PBSWS      = 0.4                 PBSWD      = 0.4                 CJSWS      = 'cjswp'
+CJSWD      = 'cjswp'             MJSWS      = 0.06                MJSWD      = 0.06
+PBSWGS     = 0.35                PBSWGD     = 0.35                CJSWGS     = 'cjswgp'
+CJSWGD     = 'cjswgp'            MJSWGS     = 0.9                 MJSWGD     = 0.9
+TPB        = 1.9E-03             TCJ        = 9.39E-04            TPBSW      = 1.6E-03
+TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthp'          WVTH0      = '0+dwvthp'
+PVTH0      = '0+dpvthp'          PVSAT      = '0+dpvsatp'         PVOFF      = '0+dpvoffp'
+LETA0      = '0+dleta0p'         WETA0      = '0+dweta0p'         PETA0      = '0+dpeta0p'
+PKT1       = '0+dpkt1p'          LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.3 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.016695868
+LK2        = '-1.3856065e-009+dlk2p'
+K3         = -3.2                K3B        = -0.649              W0         = 5e-008
+DVT0       = 28                  DVT1       = 2.23                DVT2       = 0.19
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.07960055+dvoffp'
+LVOFF      = '-5.7733602e-009+dlvoffp'
+NFACTOR    = 1.1954766           LNFACTOR   = -3.5794833e-008     ETA0       = 0.5
+ETAB       = -0.14               U0         = '57.414355+du0p'    LU0        = '-5.6939188e-007+dlu0p'
+UA         = -1.3464536e-009     LUA        = 3.1647251e-017      UB         = 2.8291339e-018
+LUB        = -4.0461787e-026     UC         = -6.5592306e-012     LUC        = 8.0827043e-018
+VSAT       = 192719.01           LVSAT      = '-0.010392048+dlvsatp'
+A0         = 10.232391           LA0        = -2.2401815e-007     AGS        = -1.3130895
+LAGS       = 1.7124662e-006      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.11863096
+LKETA      = -5.9119209e-009     DWG        = 0                   DWB        = 0
+PCLM       = 0.015206595         LPCLM      = 6.9280323e-008      PDIBLC1    = 0
+PDIBLC2    = 0.00096005496       LPDIBLC2   = 5.7733602e-010      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0052939174
+LAIGC      = -2.7712129e-011     BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.00419             BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.26
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.85525398
+LUTE       = 1.504152e-008       UA1        = 2.9155327e-009      LUA1       = -2.3655766e-017
+UB1        = -3.6361203e-018     LUB1       = 5.1618459e-027      UC1        = -1.171514e-010
+PRT        = 0                   AT         = 212319.56           LAT        = '-0.0046186882+dlatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          PVSAT      = '0+dpvsatp'
+PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'         WETA0      = '0+dweta0p'
+PETA0      = '0+dpeta0p'         LKT1       = '0+dlkt1p'          PKT1       = '0+dpkt1p'
+PAT        = '0+dpatp'           )

.MODEL pch.4 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.20704E-09
+LL         = 4.38278E-03         WL         = 0                   LLN        = -0.84142
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.38278E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.20704E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.0049650471
+LK2        = '2.9080881e-010+dlk2p'
+K3         = -3.2                K3B        = -0.649              W0         = 5e-008
+DVT0       = 28                  DVT1       = 2.23                DVT2       = 0.19
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.096258883+dvoffp'
+LVOFF      = '-3.3927694e-009+dlvoffp'
+NFACTOR    = -0.45029936         LNFACTOR   = 1.9939791e-007      ETA0       = 0.5
+ETAB       = -0.065385061        LETAB      = -1.066299e-008      U0         = '57.065782+du0p'
+LU0        = '-5.1957841e-007+dlu0p'
+UA         = -9.5609891e-010     LUA        = -2.4137131e-017     UB         = 2.5839858e-018
+LUB        = -5.4284311e-027     UC         = 4.3216824e-011      LUC        = 9.693627e-019
+VSAT       = 113216.82           LVSAT      = '0.0009693627+dlvsatp'
+A0         = 9.79408             LA0        = -1.6138047e-007     AGS        = 5.6979318
+LAGS       = 7.1054286e-007      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.21694476
+LKETA      = 8.1377998e-009      DWG        = 0                   DWB        = 0
+PCLM       = 0.63566353          LPCLM      = -1.9387254e-008     PDIBLC1    = 0
+PDIBLC2    = 0.0066957941        LPDIBLC2   = -2.4234067e-010     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0051746149
+LAIGC      = -1.066299e-011      BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.00419             BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.20573459
+LKT1       = '-7.7549016e-009+dlkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.73277073
+LUTE       = -2.4621812e-009     UA1        = 2.7445735e-009      LUA1       = 7.7549016e-019
+UB1        = -3.8414811e-018     LUB1       = 3.4509312e-026      UC1        = -1.1711843e-010
+LUC1       = -4.7111027e-021     PRT        = 0                   AT         = 258006.53
+LAT        = '-0.011147671+dlatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          PVSAT      = '0+dpvsatp'
+PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'         WETA0      = '0+dweta0p'
+PETA0      = '0+dpeta0p'         PKT1       = '0+dpkt1p'          PAT        = '0+dpatp'           )

.MODEL pch.5 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '9e-006-dxw'        WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.606405E-09
+LL         = 5.48932E-03         WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.48932E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.606405E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.1750544+dvthp'  LVTH0      = '4.0744788e-010+dlvthp'
+K1         = 0.11                K2         = -0.11697915         LK2        = '7.3340618e-009+dlk2p'
+K3         = -3.2                K3B        = -0.649              W0         = 5e-008
+DVT0       = 28                  DVT1       = 2.23                DVT2       = 0.36635993
+LDVT2      = -1.0186197e-008     DVT0W      = 0                   DVT1W      = 0
+DVT2W      = 0                   DSUB       = 1                   MINV       = 0
+VOFFL      = 0                   DVTP0      = 3e-007              DVTP1      = 3
+LPE0       = 2.3e-007            LPEB       = 5e-008              XJ         = 1.2e-007
+NGATE      = 7e+019              NDEP       = 1.7200001e+017      NSD        = 1e+020
+PHIN       = 0                   CDSC       = 0                   CDSCB      = 0
+CDSCD      = 0                   CIT        = 0                   VOFF       = '0.12364869+dvoffp'
+LVOFF      = '-1.6094191e-008+dlvoffp'
+NFACTOR    = -10.958652          LNFACTOR   = 8.0633935e-007      ETA0       = 0.16491613
+LETA0      = '1.9353774e-008+dleta0p'
+ETAB       = -0.84962377         LETAB      = 3.4633069e-008      U0         = '10.787511+du0p'
+LU0        = '2.153362e-006+dlu0p'
+UA         = -1.6914479e-009     LUA        = 1.8335154e-017      UB         = 2.40182e-018
+LUB        = 5.0930984e-027      UC         = -2.4087004e-010     LUC        = 1.7377652e-017
+VSAT       = 165271.99           LVSAT      = '-0.0020372394+dlvsatp'
+A0         = -21.217589          LA0        = 1.6297915e-006      AGS        = 28.581596
+LAGS       = -6.1117181e-007     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.10726571
+LKETA      = 1.8029569e-009      DWG        = 0                   DWB        = 0
+PCLM       = 0.65271986          LPCLM      = -2.0372394e-008     PDIBLC1    = 0
+PDIBLC2    = 0.00073640069       LPDIBLC2   = 1.0186197e-010      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.00499
+BIGC       = 0.0009927           CIGC       = 1e-010              AIGSD      = 0.00419
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.14600408         LKT1       = '-1.1204817e-008+dlkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = 0.2954575
+LUTE       = -6.1850588e-008     UA1        = 5.3963446e-009      LUA1       = -1.5238551e-016
+UB1        = -5.5225703e-018     LUB1       = 1.3160566e-025      UC1        = -3.5422775e-010
+LUC1       = 1.3690249e-017      PRT        = 0                   AT         = 170815.96
+LAT        = '-0.0061117181+dlatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp'
+PVTH0      = '0+dpvthp'          PVSAT      = '0+dpvsatp'         PVOFF      = '0+dpvoffp'
+WETA0      = '0+dweta0p'         PETA0      = '0+dpeta0p'         PKT1       = '0+dpkt1p'
+PAT        = '0+dpatp'           )

.MODEL pch.6 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.026396889
+WK2        = -1.2569206e-008     K3         = -3.2                K3B        = -0.649
+W0         = 5e-008              DVT0       = 28                  DVT1       = 2.23
+DVT2       = 0.19                DVT0W      = 0                   DVT1W      = 0
+DVT2W      = 0                   DSUB       = 1                   MINV       = 0
+VOFFL      = 0                   DVTP0      = 3e-007              DVTP1      = 3
+LPE0       = 2.3e-007            LPEB       = 5e-008              XJ         = 1.2e-007
+NGATE      = 7e+019              NDEP       = 1.7200001e+017      NSD        = 1e+020
+PHIN       = 0                   CDSC       = 0                   CDSCB      = 0
+CDSCD      = 0                   CIT        = 0                   VOFF       = '-0.093776049+dvoffp'
+WVOFF      = 6.9828923e-009      NFACTOR    = 0.75                ETA0       = 0.5
+ETAB       = -0.14886914         WETAB      = 7.9804484e-008      U0         = '46.316007+du0p'
+LU0        = '-3.5352824e-009+dlu0p'
+WU0        = 3.3421713e-005      PU0        = 3.1746836e-015      UA         = -1.7699632e-009
+LUA        = 4.7595144e-019      WUA        = 1.2229654e-015      PUA        = -4.274044e-025
+UB         = 3.0000509e-018      LUB        = -3.4978059e-029     WUB        = -6.6627818e-025
+PUB        = 3.1410297e-035      UC         = -5.8314815e-011     WUC        = 7.4816704e-017
+VSAT       = 164434.57           WVSAT      = -0.039902242        A0         = 10.599387
+LA0        = 2.3360346e-009      WA0        = -1.1663423e-006     PA0        = -2.0977591e-015
+AGS        = 0.68196254          LAGS       = 1.1544846e-006      WAGS       = -1.1228369e-007
+PAGS       = 1.1201248e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.13661728
+WKETA      = 1.9951121e-008      DWG        = 0                   DWB        = 0
+PCLM       = 0.21108642          WPCLM      = -9.9755605e-008     PDIBLC1    = 0
+PDIBLC2    = 0.00016674074       WPDIBLC2   = 2.9926681e-010      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055309965
+LAIGC      = -2.4739982e-010     WAIGC      = -2.9926681e-011     PAIGC      = 9.7212735e-031
+BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014     CIGC       = 1e-010
+AIGSD      = 0.0041863952        LAIGSD     = 2.4934348e-012      WAIGSD     = 3.2436038e-011
+PAIGSD     = -2.2435926e-017     BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.25055432         WKT1       = 4.9877802e-009      KT1L       = 0
+KT2        = -0.03875            UTE        = -0.78628237         WUTE       = -2.5960069e-007
+UA1        = 2.8102807e-009      WUA1       = 3.7930473e-016      UB1        = -3.4687092e-018
+WUB1       = -1.382478e-024      UC1        = -1.171514e-010      PRT        = 0
+AT         = 200000              JSS        = 1.5E-07             JSD        = 1.5E-07
+JSWS       = 7.00E-13            JSWD       = 7.00E-13            JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp'               CJD        = 'cjp'
+MJS        = 0.35                MJD        = 0.35                PBSWS      = 0.4
+PBSWD      = 0.4                 CJSWS      = 'cjswp'             CJSWD      = 'cjswp'
+MJSWS      = 0.06                MJSWD      = 0.06                PBSWGS     = 0.35
+PBSWGD     = 0.35                CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'
+MJSWGS     = 0.9                 MJSWGD     = 0.9                 TPB        = 1.9E-03
+TCJ        = 9.39E-04            TPBSW      = 1.6E-03             TCJSW      = 6.0E-04
+TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03             XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthp'          WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'
+LK2        = '0+dlk2p'           LVSAT      = '0+dlvsatp'         PVSAT      = '0+dpvsatp'
+LVOFF      = '0+dlvoffp'         PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'
+WETA0      = '0+dweta0p'         PETA0      = '0+dpeta0p'         LKT1       = '0+dlkt1p'
+PKT1       = '0+dpkt1p'          LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.7 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.034675705
+LK2        = '-8.2697662e-009+dlk2p'
+WK2        = -2.2188677e-008     PK2        = 9.6089559e-015      K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.093132873+dvoffp'
+LVOFF      = '-6.4247331e-010+dlvoffp'
+WVOFF      = 1.200781e-008       PVOFF      = '-5.0194252e-015+dpvoffp'
+NFACTOR    = 0.52639397          LNFACTOR   = 2.2336161e-007      WNFACTOR   = 1.198688e-007
+PNFACTOR   = -1.1973777e-013     ETA0       = 0.5                 ETAB       = -0.14886914
+WETAB      = 7.9804484e-008      U0         = '40.837173+du0p'    LU0        = '5.46931e-006+dlu0p'
+WU0        = 5.0966221e-005      PU0        = -1.7522156e-011     UA         = -2.0759805e-009
+LUA        = 3.0615874e-016      WUA        = 1.9715717e-015      PUA        = -7.4821539e-022
+UB         = 3.1662459e-018      LUB        = -1.6604829e-025     WUB        = -1.055013e-024
+PUB        = 3.8834131e-031      UC         = -9.8106972e-011     LUC        = 3.974866e-017
+WUC        = 8.1469422e-017      PUC        = -6.6454461e-024     VSAT       = 161097.46
+LVSAT      = '0.0033334568+dlvsatp'
+WVSAT      = -0.036905522        PVSAT      = '-2.9934442e-009+dpvsatp'
+A0         = 11.223136           LA0        = -6.2073097e-007     WA0        = -2.2349295e-006
+PA0        = 1.0653213e-012      AGS        = 0.98041405          LAGS       = 8.5635936e-007
+WAGS       = 5.3742577e-008      PAGS       = -5.3832305e-014     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.13699029         LKETA      = 3.726003e-010       WKETA      = 2.3307447e-008
+PKETA      = -3.3526575e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.254382            LPCLM      = -4.3248249e-008     WPCLM      = -4.8932919e-007
+PPCLM      = 3.8914775e-013      PDIBLC1    = 0                   PDIBLC2    = -0.0011685016
+LPDIBLC2   = 1.3337828e-009      WPDIBLC2   = -1.2027397e-010     PPDIBLC2   = 4.1908219e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0053200408        LAIGC      = -3.6674693e-011     WAIGC      = -3.5920121e-011
+PAIGC      = 5.9868884e-018      BIGC       = 0.00099264429       LBIGC      = 2.0885415e-014
+CIGC       = 1e-010              AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.24487924
+LKT1       = '-5.6688771e-009+dlkt1p'
+WKT1       = 7.9845002e-009      PKT1       = '-2.9934442e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.77040488
+LUTE       = -1.5860131e-008     WUTE       = -4.0246632e-007     PUTE       = 1.4270946e-013
+UA1        = 2.8041538e-009      LUA1       = 6.1201596e-018      WUA1       = 4.3443418e-016
+PUA1       = -5.5069196e-023     UB1        = -3.3912785e-018     LUB1       = -7.7346034e-026
+WUB1       = -2.0791992e-024     PUB1       = 6.9595961e-031      UC1        = -1.171514e-010
+PRT        = 0                   AT         = 200000              JSS        = 1.5E-07
+JSD        = 1.5E-07             JSWS       = 7.00E-13            JSWD       = 7.00E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp'
+CJD        = 'cjp'               MJS        = 0.35                MJD        = 0.35
+PBSWS      = 0.4                 PBSWD      = 0.4                 CJSWS      = 'cjswp'
+CJSWD      = 'cjswp'             MJSWS      = 0.06                MJSWD      = 0.06
+PBSWGS     = 0.35                PBSWGD     = 0.35                CJSWGS     = 'cjswgp'
+CJSWGD     = 'cjswgp'            MJSWGS     = 0.9                 MJSWGD     = 0.9
+TPB        = 1.9E-03             TCJ        = 9.39E-04            TPBSW      = 1.6E-03
+TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthp'          WVTH0      = '0+dwvthp'
+PVTH0      = '0+dpvthp'          LETA0      = '0+dleta0p'         WETA0      = '0+dweta0p'
+PETA0      = '0+dpeta0p'         LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.8 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16788391+dvthp' LVTH0      = '-4.3524008e-011+dlvthp'
+WVTH0      = '-1.0446034e-009+dwvthp'
+PVTH0      = '3.9162903e-016+dpvthp'
+K1         = 0.11                K2         = 0.01611876          LK2        = '-1.3126397e-009+dlk2p'
+WK2        = 5.1928153e-009      PK2        = -6.5655455e-016     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.079625755+dvoffp'
+LVOFF      = '-5.7063852e-009+dlvoffp'
+WVOFF      = 2.2679438e-010      PVOFF      = '-6.0264105e-016+dpvoffp'
+NFACTOR    = 1.2291638           LNFACTOR   = -4.0111662e-008     WNFACTOR   = -3.031178e-007
+PNFACTOR   = 3.8842827e-014      ETA0       = 0.49317101          LETA0      = '2.5602358e-009+dleta0p'
+WETA0      = '6.144726e-008+dweta0p'
+PETA0      = '-2.3037002e-014+dpeta0p'
+ETAB       = -0.14886914         WETAB      = 7.9804484e-008      U0         = '56.564054+du0p'
+LU0        = '-4.2680646e-007+dlu0p'
+WU0        = 7.6510088e-006      PU0        = -1.2829836e-012     UA         = -1.3570482e-009
+LUA        = 3.6626065e-017      WUA        = 9.5329845e-017      PUA        = -4.4799366e-023
+UB         = 2.8299337e-018      LUB        = -3.9962541e-026     WUB        = -7.196797e-027
+PUB        = -4.4922153e-033     UC         = -1.7324279e-011     LUC        = 9.4626714e-018
+WUC        = 9.6863905e-017      PUC        = -1.2416944e-023     VSAT       = 200780.95
+LVSAT      = '-0.011544155+dlvsatp'
+WVSAT      = -0.072541289        PVSAT      = '1.0366651e-008+dpvsatp'
+A0         = 10.453639           LA0        = -3.3224114e-007     WA0        = -1.9907865e-006
+PA0        = 9.7379042e-013      AGS        = -1.4109979          LAGS       = 1.7529162e-006
+WAGS       = 8.8098027e-007      PAGS       = -3.6396942e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.12238537         LKETA      = -5.1028864e-009     WKETA      = 3.3782141e-008
+PKETA      = -7.2796925e-015     DWG        = 0                   DWB        = 0
+PCLM       = -0.0013802732       LPCLM      = 5.263879e-008       WPCLM      = 1.4924864e-007
+PPCLM      = 1.4974051e-013      PDIBLC1    = 0                   PDIBLC2    = 0.00091748067
+LPDIBLC2   = 5.5173366e-010      WPDIBLC2   = 3.8308345e-010      PPDIBLC2   = 2.3037002e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052975004        LAIGC      = -2.8224176e-011     WAIGC      = -3.2240573e-011
+PAIGC      = 4.6074003e-018      BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.2593171          LKT1       = '-2.5602358e-010+dlkt1p'
+WKT1       = -6.144726e-009      PKT1       = '2.3037002e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.85201099
+LUTE       = 1.4734563e-008      WUTE       = -2.9180417e-008     PUTE       = 2.7619983e-015
+UA1        = 2.823717e-009       LUA1       = -1.2141986e-018     WUA1       = 8.2615818e-016
+PUA1       = -2.0192923e-022     UB1        = -3.5641415e-018     LUB1       = -1.2538523e-026
+WUB1       = -6.4766597e-025     PUB1       = 1.5926792e-031      UC1        = -1.171514e-010
+PRT        = 0                   AT         = 211636.66           LAT        = '-0.0043626646+dlatp'
+WAT        = 0.006144726         PAT        = '-2.3037002e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.9 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.20704E-09
+LL         = 4.38278E-03         WL         = 0                   LLN        = -0.84142
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.38278E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.20704E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16846671+dvthp' LVTH0      = '3.9763134e-011+dlvthp'
+WVTH0      = '4.199494e-009+dwvthp'
+PVTH0      = '-3.5778868e-016+dpvthp'
+K1         = 0.11                K2         = 0.0048534084        LK2        = '2.9725679e-010+dlk2p'
+WK2        = 1.0045248e-009      PK2        = -5.8018943e-017     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.095138622+dvoffp'
+LVOFF      = '-3.4894895e-009+dlvoffp'
+WVOFF      = -1.0080112e-008     PVOFF      = '8.7028695e-016+dpvoffp'
+NFACTOR    = -0.44460883         LNFACTOR   = 1.99082e-007        WNFACTOR   = -5.1203415e-008
+PNFACTOR   = 2.8425225e-015      ETA0       = 0.51409447          LETA0      = '-4.2987172e-010+dleta0p'
+WETA0      = '-1.2682208e-007+dweta0p'
+PETA0      = '3.8679857e-015+dpeta0p'
+ETAB       = -0.076510261        LETAB      = -1.0340582e-008     WETAB      = 1.0010455e-007
+PETAB      = -2.9010202e-015     U0         = '58.210401+du0p'    LU0        = '-6.6208071e-007+dlu0p'
+WU0        = -1.0299275e-005     PU0        = 1.2822358e-012      UA         = -8.8120652e-010
+LUA        = -3.1374992e-017     WUA        = -6.7388169e-016     PUA        = 6.5126269e-023
+UB         = 2.5811896e-018      LUB        = -4.4152862e-027     WUB        = 2.5160371e-026
+PUB        = -9.1162779e-033     UC         = 4.2108184e-011      LUC        = 9.6936238e-019
+WUC        = 9.9755408e-018      PUC        = 2.8098694e-030      VSAT       = 114344.85
+LVSAT      = '0.00080816049+dlvsatp'
+WVSAT      = -0.010149947        PVSAT      = '1.4504975e-009+dpvsatp'
+A0         = 9.1200214           LA0        = -1.4165801e-007     WA0        = 6.0651793e-006
+PA0        = -1.7746269e-013     AGS        = 5.9710622           LAGS       = 6.9796888e-007
+WAGS       = -2.4576273e-006     PAGS       = 1.1314064e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.21748569         LKETA      = 8.4876053e-009      WKETA      = 4.8672132e-009
+PKETA      = -3.1475498e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.46502577          LPCLM      = -1.4013851e-008     WPCLM      = 1.5353986e-006
+PPCLM      = -4.8349878e-014     PDIBLC1    = 0                   PDIBLC2    = 0.0064364645
+LPDIBLC2   = -2.369672e-010      WPDIBLC2   = 2.3334479e-009      PPDIBLC2   = -4.8350524e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0051716069        LAIGC      = -1.0233115e-011     WAIGC      = 2.7066689e-011
+PAIGC      = -3.8680166e-018     BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.20834728         LKT1       = '-7.5399632e-009+dlkt1p'
+WKT1       = 2.3508954e-008      PKT1       = '-1.9340153e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.70611646
+LUTE       = -6.1147714e-009     WUTE       = -2.398351e-007      PUTE       = 3.2866006e-014
+UA1        = 2.9600683e-009      LUA1       = -2.0699741e-017     WUA1       = -1.9390222e-015
+PUA1       = 1.9323413e-022      UB1        = -3.9807429e-018     LUB1       = 4.6996698e-026
+WUB1       = 1.253078e-024       PUB1       = -1.123615e-031      UC1        = -1.1711843e-010
+LUC1       = -4.7111012e-021     PRT        = 0                   AT         = 259491.15
+LAT        = '-0.011201401+dlatp'
+WAT        = -0.013358643        PAT        = '4.834659e-010+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.10 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '9e-007-dxw'        WMAX       = '9e-006-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.606405E-09
+LL         = 5.48932E-03         WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.48932E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.606405E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17874304+dvthp' LVTH0      = '6.3330368e-010+dlvthp'
+WVTH0      = '3.319045e-008+dwvthp'
+PVTH0      = '-2.0322505e-015+dpvthp'
+K1         = 0.11                K2         = -0.12128067         LK2        = '7.5825078e-009+dlk2p'
+WK2        = 3.8705051e-008      PK2        = -2.2355175e-015     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.36636008          LDVT2      = -1.0186204e-008
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '0.13130639+dvoffp' LVOFF      = '-1.6568499e-008+dlvoffp'
+WVOFF      = -6.8903964e-008     PVOFF      = '4.267819e-015+dpvoffp'
+NFACTOR    = -11.724093          LNFACTOR   = 8.505624e-007       WNFACTOR   = 6.8874364e-006
+PNFACTOR   = -3.9791908e-013     ETA0       = 0.15006066          LETA0      = '2.0595993e-008+dleta0p'
+WETA0      = '1.3366955e-007+dweta0p'
+PETA0      = '-1.1177482e-014+dpeta0p'
+ETAB       = -0.86689861         LETAB      = 3.5310659e-008      WETAB      = 1.5543901e-007
+PETAB      = -6.0969551e-015     U0         = '8.0688663+du0p'    LU0        = '2.2339939e-006+dlu0p'
+WU0        = 2.4462361e-005      PU0        = -7.2552567e-013     UA         = -1.7770625e-009
+LUA        = 2.0367867e-017      WUA        = 7.7036054e-016      PUA        = -1.8290344e-023
+UB         = 2.397013e-018       LUB        = 6.2223795e-027      WUB        = 4.3253272e-026
+PUB        = -1.0161271e-032     UC         = -2.6829573e-010     LUC        = 1.8897671e-017
+WUC        = 2.4677638e-016      PUC        = -1.3677135e-023     VSAT       = 158525.57
+LVSAT      = '-0.0017436286+dlvsatp'
+WVSAT      = 0.060704225         PVSAT      = '-2.6419101e-009+dpvsatp'
+A0         = -22.997043          LA0        = 1.7133592e-006      WA0        = 1.6011527e-005
+PA0        = -7.5194171e-013     AGS        = 24.749739           LAGS       = -3.8664925e-007
+WAGS       = 3.4479052e-005      PAGS       = -2.0202541e-012     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.067749576        LKETA      = -1.6085576e-010     WKETA      = -3.5556616e-007
+PKETA      = 1.7670386e-014      DWG        = 0                   DWB        = 0
+PCLM       = 0.54664774          LPCLM      = -1.8728179e-008     WPCLM      = 9.5443697e-007
+PPCLM      = -1.4794642e-014     PDIBLC1    = 0                   PDIBLC2    = -0.00034961611
+LPDIBLC2   = 1.5498326e-010      WPDIBLC2   = 9.7719792e-009      PPDIBLC2   = -4.7798536e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0049944346        WAIGC      = -3.9902242e-011     BIGC       = 0.0009927
+CIGC       = 1e-010              AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.12886275         LKT1       = '-1.2130832e-008+dlkt1p'
+WKT1       = -1.5423766e-007     PKT1       = '8.3322853e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = 0.19161489
+LUTE       = -5.7965914e-008     WUTE       = 9.3437585e-007      PUTE       = -3.495429e-014
+UA1        = 4.7985476e-009      LUA1       = -1.2688652e-016     WUA1       = 5.3789772e-015
+PUA1       = -2.2943988e-022     UB1        = -5.333796e-018      LUB1       = 1.2514628e-025
+WUB1       = -1.6985916e-024     PUB1       = 5.8121493e-032      UC1        = -3.6459043e-010
+LUC1       = 1.4288775e-017      WUC1       = 9.3243448e-017      PUC1       = -5.3855407e-024
+PRT        = 0                   AT         = 173325.56           LAT        = '-0.00622465+dlatp'
+WAT        = -0.022581361        PAT        = '1.0161613e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.11 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.010008889
+WK2        = 2.1472178e-009      K3         = -3.2                K3B        = -0.649
+W0         = 5e-008              DVT0       = 28                  DVT1       = 2.23
+DVT2       = 0.19                DVT0W      = 0                   DVT1W      = 0
+DVT2W      = 0                   DSUB       = 1                   MINV       = 0
+VOFFL      = 0                   DVTP0      = 3e-007              DVTP1      = 3
+LPE0       = 2.3e-007            LPEB       = 5e-008              XJ         = 1.2e-007
+NGATE      = 7e+019              NDEP       = 1.7200001e+017      NSD        = 1e+020
+PHIN       = 0                   CDSC       = 0                   CDSCB      = 0
+CDSCD      = 0                   CIT        = 0                   VOFF       = '-0.089661389+dvoffp'
+WVOFF      = 3.2879272e-009      NFACTOR    = 0.51618236          WNFACTOR   = 2.0996824e-007
+ETA0       = 0.58966667          WETA0      = '-8.0520667e-008+dweta0p'
+ETAB       = -0.00022222222      WETAB      = -5.3680444e-008     U0         = '76.826375+du0p'
+WU0        = 6.0234022e-006      UA         = -4.6910387e-010     WUA        = 5.4793777e-017
+UB         = 2.2416063e-018      WUB        = 1.4805067e-026      UC         = 2.5e-011
+VSAT       = 105055.56           WVSAT      = 0.013420111         A0         = 8.71442
+WA0        = 5.2635823e-007      AGS        = 0.39456311          LAGS       = 1.3947139e-006
+WAGS       = 1.4580099e-007      PAGS       = -1.0371341e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.1144             DWG        = 0                   DWB        = 0
+PCLM       = -0.049444444        WPCLM      = 1.3420111e-007      PDIBLC1    = 0
+PDIBLC2    = 0.0010977778        WPDIBLC2   = -5.3680444e-010     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055481428
+LAIGC      = -2.9781691e-010     WAIGC      = -4.5324086e-011     PAIGC      = 4.5274542e-017
+BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014     CIGC       = 1e-010
+AIGSD      = 0.0041814415        LAIGSD     = -5.6102283e-011     WAIGSD     = 3.6884498e-011
+PAIGSD     = 3.0183028e-017      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.26891111         WKT1       = 2.1472178e-008      KT1L       = 0
+KT2        = -0.03875            UTE        = -1.3374507          WUTE       = 2.3534849e-007
+UA1        = 5.1196414e-010      WUA1       = 2.443193e-015       UB1        = -2.5654489e-018
+WUB1       = -2.1936057e-024     UC1        = -1.171514e-010      PRT        = 0
+AT         = 170111.11           WAT        = 0.026840222         JSS        = 1.5E-07
+JSD        = 1.5E-07             JSWS       = 7.00E-13            JSWD       = 7.00E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp'
+CJD        = 'cjp'               MJS        = 0.35                MJD        = 0.35
+PBSWS      = 0.4                 PBSWD      = 0.4                 CJSWS      = 'cjswp'
+CJSWD      = 'cjswp'             MJSWS      = 0.06                MJSWD      = 0.06
+PBSWGS     = 0.35                PBSWGD     = 0.35                CJSWGS     = 'cjswgp'
+CJSWGD     = 'cjswgp'            MJSWGS     = 0.9                 MJSWGD     = 0.9
+TPB        = 1.9E-03             TCJ        = 9.39E-04            TPBSW      = 1.6E-03
+TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthp'          WVTH0      = '0+dwvthp'
+PVTH0      = '0+dpvthp'          LU0        = '0+dlu0p'           LK2        = '0+dlk2p'
+LVSAT      = '0+dlvsatp'         PVSAT      = '0+dpvsatp'         LVOFF      = '0+dlvoffp'
+PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'         PETA0      = '0+dpeta0p'
+LKT1       = '0+dlkt1p'          PKT1       = '0+dpkt1p'          LAT        = '0+dlatp'
+PAT        = '0+dpatp'           )

.MODEL pch.12 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.0057349436
+LK2        = '4.2692735e-009+dlk2p'
+WK2        = 3.8001263e-009      PK2        = -1.6511017e-015     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.079890246+dvoffp'
+LVOFF      = '-9.760462e-009+dlvoffp'
+WVOFF      = 1.1593128e-010      PVOFF      = '3.1685286e-015+dpvoffp'
+NFACTOR    = 1.0811023           LNFACTOR   = -5.6430238e-007     WNFACTOR   = -3.7825925e-007
+PNFACTOR   = 5.875845e-013       ETA0       = 0.58966667          WETA0      = '-8.0520667e-008+dweta0p'
+ETAB       = -0.00022222222      WETAB      = -5.3680444e-008     U0         = '91.40278+du0p'
+LU0        = '-1.4560471e-005+dlu0p'
+WU0        = 5.5583059e-006      PU0        = 4.6458781e-013      UA         = 6.9005531e-011
+LUA        = -5.3752119e-016     WUA        = 4.5374295e-017      PUA        = 9.4091857e-024
+UB         = 2.0036304e-018      LUB        = 2.3771575e-025      WUB        = -1.0984338e-026
+PUB        = 2.5761214e-032      UC         = -7.3837851e-012     LUC        = 3.2348386e-017
+VSAT       = 105055.56           WVSAT      = 0.013420111         A0         = 4.5218288
+LA0        = 4.1880082e-006      WA0        = 3.7828444e-006      PA0        = -3.2529265e-012
+AGS        = 1.1039317           LAGS       = 6.8612078e-007      WAGS       = -5.717624e-008
+PAGS       = 9.9041941e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.13940848
+LKETA      = 2.4981143e-008      WKETA      = 2.547898e-008       PKETA      = -2.5451129e-014
+DWG        = 0                   DWB        = 0                   PCLM       = -1.0235949
+LPCLM      = 9.7308561e-007      WPCLM      = 6.5829405e-007      PPCLM      = -5.2352006e-013
+PDIBLC1    = 0                   PDIBLC2    = -0.0025902086       LPDIBLC2   = 3.6839551e-009
+WPDIBLC2   = 1.1564189e-009      PPDIBLC2   = -1.6913725e-015     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0052531042
+LAIGC      = -3.1008039e-012     WAIGC      = 2.4188905e-011      PAIGC      = -2.4162464e-017
+BIGC       = 0.00099264429       LBIGC      = 2.0885415e-014      CIGC       = 1e-010
+AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010      NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.26528621         LKT1       = '-3.6209387e-009+dlkt1p'
+WKT1       = 2.6309959e-008      PKT1       = '-4.8324928e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -1.4424957
+LUTE       = 1.0493011e-007      WUTE       = 2.010712e-007       PUTE       = 3.4239823e-014
+UA1        = -7.3179275e-010     LUA1       = 1.2423973e-015      WUA1       = 3.6097142e-015
+PUA1       = -1.1652461e-021     UB1        = -1.8264437e-018     LUB1       = -7.3819739e-025
+WUB1       = -3.4844209e-024     PUB1       = 1.2894041e-030      UC1        = -1.171514e-010
+PRT        = 0                   AT         = 170111.11           WAT        = 0.026840222
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LVSAT      = '0+dlvsatp'
+PVSAT      = '0+dpvsatp'         LETA0      = '0+dleta0p'         PETA0      = '0+dpeta0p'
+LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.13 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17981754+dvthp' LVTH0      = '4.4304766e-009+dlvthp'
+WVTH0      = '9.6717973e-009+dwvthp'
+PVTH0      = '-3.6260235e-015+dpvthp'
+K1         = 0.11                K2         = 0.027038548         LK2        = '-3.7175949e-009+dlk2p'
+WK2        = -4.6131543e-009     PK2        = 1.5030952e-015      K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.10031383+dvoffp'
+LVOFF      = '-2.1035181e-009+dlvoffp'
+WVOFF      = 1.8804689e-008      PVOFF      = '-3.8380158e-015+dpvoffp'
+NFACTOR    = -1.7595289          LNFACTOR   = 5.0066985e-007      WNFACTOR   = 2.3807283e-006
+PNFACTOR   = -4.4677897e-013     ETA0       = 0.75252441          LETA0      = '-6.1056492e-008+dleta0p'
+WETA0      = '-1.7145209e-007+dweta0p'
+PETA0      = '3.409082e-014+dpeta0p'
+ETAB       = -0.00022222222      WETAB      = -5.3680444e-008     U0         = '64.726806+du0p'
+LU0        = '-4.5594646e-006+dlu0p'
+WU0        = 3.2085735e-007      PU0        = 2.4281434e-012      UA         = -1.1174764e-009
+LUA        = -9.2700935e-017     WUA        = -1.1980563e-016     PUA        = 7.133628e-023
+UB         = 2.755524e-018       LUB        = -4.4174341e-026     WUB        = 5.9623146e-026
+PUB        = -7.100188e-034      UC         = 1.2276106e-010      LUC        = -1.6443813e-017
+WUC        = -2.8932727e-017     PUC        = 1.0847079e-023      VSAT       = 105055.56
+WVSAT      = 0.013420111         A0         = 10.139145           LA0        = 2.0820375e-006
+WA0        = -1.7083715e-006     PA0        = -1.1942318e-012     AGS        = 1.0386341
+LAGS       = 7.1060127e-007      WAGS       = -1.3187893e-006     PAGS       = 5.7202939e-013
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.0084523933       LKETA      = -2.4115197e-008
+WKETA      = -6.852967e-008      PKETA      = 9.7933627e-015      DWG        = 0
+DWB        = 0                   PCLM       = 0.11224765          LPCLM      = 5.472504e-007
+WPCLM      = 4.7210765e-008      PPCLM      = -2.9442072e-013     PDIBLC1    = 0
+PDIBLC2    = 0.0064610054        LPDIBLC2   = 2.9059246e-010      WPDIBLC2   = -4.5950018e-009
+PPDIBLC2   = 4.6487481e-016      PDIBLCB    = 0                   DROUT      = 0
+PVAG       = 3                   DELTA      = 0.020306            PSCBE1     = 9.264e+008
+PSCBE2     = 1e-020              FPROUT     = 80                  PDITS      = 0.45
+PDITSD     = 0.43                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = 130                 RDW        = 130
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.5                 BETA0      = 14.31
+AGIDL      = 5.16e-008           BGIDL      = 2.3e+009            CGIDL      = 0.5
+EGIDL      = 0.53                AIGBACC    = 0.01095             BIGBACC    = 0.00456
+CIGBACC    = 0.2247              NIGBACC    = 4.046               AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0052880202        LAIGC      = -1.6191068e-011
+WAIGC      = -2.3727346e-011     PAIGC      = -6.1983309e-018     BIGC       = 0.0009927
+CIGC       = 1e-010              AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.29030967         LKT1       = '5.7605305e-009+dlkt1p'
+WKT1       = 2.1686605e-008      PKT1       = '-3.0991654e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -1.6897847
+LUTE       = 1.9764046e-007      WUTE       = 7.2314034e-007      PUTE       = -1.614875e-013
+UA1        = 2.5730261e-009      LUA1       = 3.3979638e-018      WUA1       = 1.0512786e-015
+PUA1       = -2.0607095e-022     UB1        = -4.3058309e-018     LUB1       = 1.9134199e-025
+WUB1       = 1.8371186e-026      PUB1       = -2.3816776e-032     UC1        = -1.171514e-010
+PRT        = 0                   AT         = 188590.45           LAT        = '-0.0069280323+dlatp'
+WAT        = 0.026840222         JSS        = 1.5E-07             JSD        = 1.5E-07
+JSWS       = 7.00E-13            JSWD       = 7.00E-13            JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp'               CJD        = 'cjp'
+MJS        = 0.35                MJD        = 0.35                PBSWS      = 0.4
+PBSWD      = 0.4                 CJSWS      = 'cjswp'             CJSWD      = 'cjswp'
+MJSWS      = 0.06                MJSWD      = 0.06                PBSWGS     = 0.35
+PBSWGD     = 0.35                CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'
+MJSWGS     = 0.9                 MJSWGD     = 0.9                 TPB        = 1.9E-03
+TCJ        = 9.39E-04            TPBSW      = 1.6E-03             TCJSW      = 6.0E-04
+TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03             XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVSAT      = '0+dlvsatp'         PVSAT      = '0+dpvsatp'         PAT        = '0+dpatp'           )

.MODEL pch.14 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.20704E-09
+LL         = 4.38278E-03         WL         = 0                   LLN        = -0.84142
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.38278E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.20704E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.13951336+dvthp' LVTH0      = '-1.3292681e-009+dlvthp'
+WVTH0      = '-2.1800615e-008+dwvthp'
+PVTH0      = '8.7160139e-016+dpvthp'
+K1         = 0.11                K2         = -0.0030364289       LK2        = '5.8032682e-010+dlk2p'
+WK2        = 8.0895987e-009      PK2        = -3.1221583e-016     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.19                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.094355823+dvoffp'
+LVOFF      = '-2.9549589e-009+dlvoffp'
+WVOFF      = -1.0783065e-008     PVOFF      = '3.9027848e-016+dpvoffp'
+NFACTOR    = 0.48643852          LNFACTOR   = 1.7970561e-007      WNFACTOR   = -8.8728393e-007
+PNFACTOR   = 2.0242524e-014      ETA0       = 0.26773364          LETA0      = '8.223455e-009+dleta0p'
+WETA0      = '9.4409955e-008+dweta0p'
+PETA0      = '-3.9027016e-015+dpeta0p'
+ETAB       = 0.13529125          LETAB      = -1.9365811e-008     WETAB      = -9.0093207e-008
+PETAB      = 5.203635e-015       U0         = '20.468333+du0p'    LU0        = '1.7653766e-006+dlu0p'
+WU0        = 2.3593102e-005      PU0        = -8.9762089e-013     UA         = -2.1610359e-009
+LUA        = 5.6430918e-017      WUA        = 4.7540508e-016      PUA        = -1.3723437e-023
+UB         = 2.1451675e-018      LUB        = 4.3049816e-026      WUB        = 4.1670822e-025
+PUB        = -5.173994e-032      UC         = -1.4294401e-011     LUC        = 3.1423578e-018
+WUC        = 6.0625062e-017      PUC        = -1.951347e-024      VSAT       = 77960.412
+LVSAT      = '0.003872083+dlvsatp'
+WVSAT      = 0.022523275         PVSAT      = '-1.300905e-009+dpvsatp'
+A0         = 33.347178           LA0        = -1.2345505e-006     WA0        = -1.5690807e-005
+PA0        = 8.0395475e-013      AGS        = -7.3574406          LAGS       = 1.9104583e-006
+WAGS       = 9.5113682e-006      PAGS       = -9.7567485e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.17935342         LKETA      = 3.0773876e-010      WKETA      = -2.9375561e-008
+PKETA      = 4.1979704e-015      DWG        = 0                   DWB        = 0
+PCLM       = 5.1260881           LPCLM      = -1.6926199e-007     WPCLM      = -2.6502354e-006
+PPCLM      = 9.106295e-014       PDIBLC1    = 0                   PDIBLC2    = 0.0096657329
+LPDIBLC2   = -1.673852e-010      WPDIBLC2   = -5.664351e-010      PPDIBLC2   = -1.1083516e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052866077        LAIGC      = -1.5989205e-011     WAIGC      = -7.620405e-011
+PAIGC      = 1.3009522e-018      BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.1517565          LKT1       = '-1.4039673e-008+dlkt1p'
+WKT1       = -2.7309558e-008     PKT1       = '3.9027243e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.57698367
+LUTE       = 3.8613524e-008      WUTE       = -3.5579635e-007     PUTE       = -7.300003e-015
+UA1        = 1.1701434e-009      LUA1       = 2.0387958e-016      WUA1       = -3.3166962e-016
+PUA1       = -8.4381065e-024     UB1        = -3.4364445e-018     LUB1       = 6.7100662e-026
+WUB1       = 7.6429797e-025      PUB1       = -1.3041486e-031     UC1        = -9.6884822e-011
+LUC1       = -2.8962339e-018     WUC1       = -1.8169784e-017     PUC1       = 2.5965875e-024
+PRT        = 0                   AT         = 194452.43           LAT        = '-0.0077657496+dlatp'
+WAT        = 0.045046127         PAT        = '-2.6017494e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.15 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '5.4e-007-dxw'      WMAX       = '9e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.606405E-09
+LL         = 5.48932E-03         WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.48932E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.606405E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.0447003+dvthp'  LVTH0      = '-6.8054865e-009+dlvthp'
+WVTH0      = '-8.7179934e-008+dwvthp'
+PVTH0      = '4.647783e-015+dpvthp'
+K1         = 0.11                K2         = -0.038997511        LK2        = '2.657388e-009+dlk2p'
+WK2        = -3.5185223e-008     PK2        = 2.18724e-015        K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.26093244          LDVT2      = -4.0969596e-009
+WDVT2      = 9.467265e-008       PDVT2      = -5.4680792e-015     DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '0.14866729+dvoffp' LVOFF      = '-1.6991528e-008+dlvoffp'
+WVOFF      = -8.4494057e-008     PVOFF      = '4.6476996e-015+dpvoffp'
+NFACTOR    = -1.3480006          LNFACTOR   = 2.8566003e-007      WNFACTOR   = -2.4302945e-006
+PNFACTOR   = 1.0936325e-013      ETA0       = 0.53258604          LETA0      = '-7.073872e-009+dleta0p'
+WETA0      = '-2.0983825e-007+dweta0p'
+PETA0      = '1.3670056e-014+dpeta0p'
+ETAB       = -0.60049787         LETAB      = 2.3132079e-008      WETAB      = -8.3788848e-008
+PETAB      = 4.83941e-015        U0         = '-26.368598+du0p'   LU0        = '4.4705869e-006+dlu0p'
+WU0        = 5.5387204e-005      PU0        = -2.7339862e-012     UA         = -3.6614807e-009
+LUA        = 1.4309343e-016      WUA        = 2.462568e-015       PUA        = -1.284979e-022
+UB         = 5.350736e-018       LUB        = -1.4209737e-025     WUB        = -2.6091899e-024
+PUB        = 1.2302986e-031      UC         = -1.425064e-010      LUC        = 1.0547638e-017
+WUC        = 1.3381755e-016      PUC        = -6.1788052e-024     VSAT       = 268293.6
+LVSAT      = '-0.0071212121+dlvsatp'
+WVSAT      = -0.037867465        PVSAT      = '2.1871599e-009+dpvsatp'
+A0         = 28.538647           LA0        = -9.5681414e-007     WA0        = -3.0267523e-005
+PA0        = 1.6458739e-012      AGS        = 134.30746           LAGS       = -6.2718378e-006
+WAGS       = -6.3903779e-005     PAGS       = 3.2646453e-012      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.8032641          LKETA      = 3.6343634e-008      WKETA      = 3.0492589e-007
+PKETA      = -1.5110646e-014     DWG        = 0                   DWB        = 0
+PCLM       = 3.7159073           LPCLM      = -8.781263e-008      WPCLM      = -1.8915581e-006
+PPCLM      = 4.7243195e-014      PDIBLC1    = 0                   PDIBLC2    = 0.024590871
+LPDIBLC2   = -1.0294317e-009     WPDIBLC2   = -1.2624578e-008     PPDIBLC2   = 5.8561925e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0050097778        WAIGC      = -5.3680444e-011     BIGC       = 0.0009927
+CIGC       = 1e-010              AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.42979276         LKT1       = '2.019174e-009+dlkt1p'
+WKT1       = 1.1599749e-007      PKT1       = '-4.37442e-015+dpkt1p'
+KT1L       = 0                   KT2        = 0.17771193          LKT2       = -1.2502408e-008
+WKT2       = -1.9438281e-007     PKT2       = 1.1227162e-014      UTE        = 5.0398378
+LUTE       = -2.858034e-007      WUTE       = -3.4193284e-006     PUTE       = 1.6964377e-013
+UA1        = 1.4736184e-008      LUA1       = -5.7967027e-016     WUA1       = -3.5450201e-015
+PUA1       = 1.7715993e-022      UB1        = 3.5888392e-018      LUB1       = -3.3866451e-025
+WUB1       = -9.7111179e-024     PUB1       = 4.7462359e-031      UC1        = -7.8322986e-010
+LUC1       = 3.6745719e-017      WUC1       = 4.6918166e-016      PUC1       = -2.5551876e-023
+PRT        = 0                   AT         = 153449.44           LAT        = '-0.005397475+dlatp'
+WAT        = -0.0047326122       PAT        = '2.7335805e-010+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.16 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.02040679
+WK2        = -3.4468531e-009     K3         = -3.2                K3B        = -0.649
+W0         = 5e-008              DVT0       = 28                  DVT1       = 2.23
+DVT2       = 0.17679012          WDVT2      = 7.1069136e-009      DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.09051821+dvoffp'
+WVOFF      = 3.7488969e-009      NFACTOR    = 1.373069            WNFACTOR   = -2.5103676e-007
+ETA0       = 0.43339506          WETA0      = '3.5534568e-009+dweta0p'
+ETAB       = -0.086790123        WETAB      = -7.1069136e-009     U0         = '80.328059+du0p'
+WU0        = 4.1394964e-006      UA         = -2.8595777e-010     WUA        = -4.3738824e-017
+UB         = 2.3184626e-018      WUB        = -2.6543612e-026     UC         = 5.1191358e-012
+WUC        = 1.0695905e-017      VSAT       = 149814.81           WVSAT      = -0.01066037
+A0         = 10.216408           WA0        = -2.817113e-007      AGS        = 0.65985136
+LAGS       = 1.2530559e-006      WAGS       = 3.0759088e-009      PAGS       = -2.7501414e-014
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.17120247         WKETA      = 3.0559728e-008
+DWG        = 0                   DWB        = 0                   PCLM       = 0.2
+PDIBLC1    = 0                   PDIBLC2    = 0.0001              PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 3                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 80
+PDITS      = 0.45                PDITSD     = 0.43                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = 130
+RDW        = 130                 PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.5
+BETA0      = 14.31               AGIDL      = 5.16e-008           BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055241725
+LAIGC      = -2.2109103e-010     WAIGC      = -3.2428048e-011     PAIGC      = 3.9960208e-018
+BIGC       = 0.0010044681        LBIGC      = -1.0152556e-013     WBIGC      = -6.3289074e-012
+PBIGC      = 3.3566575e-020      CIGC       = 1e-010              AIGSD      = 0.0042301852
+WAIGSD     = 1.066037e-011       BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp'             XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop'              CGDO       = 'cgop'
+CGBO       = 0                   CGDL       = 'cglp'              CGSL       = 'cglp'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 2.175               VOFFCV     = -0.03885
+KT1        = -0.229              KT1L       = 0                   KT2        = -0.03875
+UTE        = -0.9                UA1        = 5.053215e-009       UB1        = -6.642783e-018
+UC1        = -1.171514e-010      PRT        = 0                   AT         = 220000
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LU0        = '0+dlu0p'
+LK2        = '0+dlk2p'           LVSAT      = '0+dlvsatp'         PVSAT      = '0+dpvsatp'
+LVOFF      = '0+dlvoffp'         PVOFF      = '0+dpvoffp'         LETA0      = '0+dleta0p'
+PETA0      = '0+dpeta0p'         LKT1       = '0+dlkt1p'          PKT1       = '0+dpkt1p'
+LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.17 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.019879781
+LK2        = '5.2643278e-010+dlk2p'
+WK2        = -3.8097964e-009     PK2        = 3.6254658e-016      K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.17679012          WDVT2      = 7.1069136e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.088845393+dvoffp'
+LVOFF      = '-1.6709888e-009+dlvoffp'
+WVOFF      = 4.9338001e-009      PVOFF      = '-1.183608e-015+dpvoffp'
+NFACTOR    = 0.76654825          LNFACTOR   = 6.0585775e-007      WNFACTOR   = -2.0902919e-007
+PNFACTOR   = -4.1961653e-014     ETA0       = 0.43339506          WETA0      = '3.5534568e-009+dweta0p'
+ETAB       = -0.086790123        WETAB      = -7.1069136e-009     U0         = '93.597781+du0p'
+LU0        = '-1.3255217e-005+dlu0p'
+WU0        = 4.3773951e-006      PU0        = -2.3763862e-013     UA         = 2.7342819e-010
+LUA        = -5.587745e-016      WUA        = -6.4605098e-017     PUA        = 2.0843464e-023
+UB         = 2.0324312e-018      LUB        = 2.8571875e-025      WUB        = -2.6479136e-026
+PUB        = -6.4405334e-035     UC         = -3.9209318e-011     LUC        = 4.4279998e-017
+WUC        = 1.7122137e-017      PUC        = -6.4192072e-024     VSAT       = 149814.81
+WVSAT      = -0.01066037         A0         = 13.628875           LA0        = -3.4087366e-006
+WA0        = -1.1167463e-006     PA0        = 8.3412223e-013      AGS        = 1.0629622
+LAGS       = 8.5038572e-007      WAGS       = -3.5134674e-008     PAGS       = 1.06674e-014
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.16028104         LKETA      = -1.0909495e-008
+WKETA      = 3.6708415e-008      PKETA      = -6.1419657e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.2447806           LPCLM      = -4.4731652e-008
+WPCLM      = -2.4091964e-008     PPCLM      = 2.4065629e-014      PDIBLC1    = 0
+PDIBLC2    = 0.0001657263        LPDIBLC2   = -6.5654458e-011     WPDIBLC2   = -3.2627409e-010
+PPDIBLC2   = 3.2591744e-016      PDIBLCB    = 0                   DROUT      = 0
+PVAG       = 3                   DELTA      = 0.020306            PSCBE1     = 9.264e+008
+PSCBE2     = 1e-020              FPROUT     = 80                  PDITS      = 0.45
+PDITSD     = 0.43                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = 130                 RDW        = 130
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.5                 BETA0      = 14.31
+AGIDL      = 5.16e-008           BGIDL      = 2.3e+009            CGIDL      = 0.5
+EGIDL      = 0.53                AIGBACC    = 0.01095             BIGBACC    = 0.00456
+CIGBACC    = 0.2247              NIGBACC    = 4.046               AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0053628095        LAIGC      = -5.9904419e-011
+WAIGC      = -3.4832536e-011     PAIGC      = 6.3978809e-018      BIGC       = 0.0010043123
+LBIGC      = 5.4182936e-014      WBIGC      = -6.2773704e-012     PBIGC      = -1.7914066e-020
+CIGC       = 1e-010              AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.23622458
+LKT1       = '7.2166858e-009+dlkt1p'
+WKT1       = 1.0674803e-008      PKT1       = '-1.0663135e-014+dpkt1p'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -1.2822066
+LUTE       = 3.8178882e-007      WUTE       = 1.1483569e-007      PUTE       = -1.1471017e-013
+UA1        = 5.4604543e-009      LUA1       = -4.0679412e-016     WUA1       = 2.7828529e-016
+PUA1       = -2.779811e-022      UB1        = -7.9350428e-018     LUB1       = 1.2908472e-024
+WUB1       = -1.9799455e-025     PUB1       = 1.9777812e-031      UC1        = -1.1717069e-010
+LUC1       = 1.9264994e-020      WUC1       = 1.0375909e-020      PUC1       = -1.0364567e-026
+PRT        = 0                   AT         = 180316.72           LAT        = '0.039639906+dlatp'
+WAT        = 0.021349607         PAT        = '-2.132627e-008+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LVSAT      = '0+dlvsatp'
+PVSAT      = '0+dpvsatp'         LETA0      = '0+dleta0p'         PETA0      = '0+dpeta0p'         )

.MODEL pch.18 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.15777172+dvthp' LVTH0      = '-3.8346516e-009+dlvthp'
+WVTH0      = '-2.1888513e-009+dwvthp'
+PVTH0      = '8.2061544e-016+dpvthp'
+K1         = 0.11                K2         = 0.024968412         LK2        = '-1.3813299e-009+dlk2p'
+WK2        = -3.4994208e-009     PK2        = 2.4618463e-016      K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.17679012          WDVT2      = 7.1069136e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.065948888+dvoffp'
+LVOFF      = '-1.0255046e-008+dlvoffp'
+WVOFF      = 3.1634872e-010      PVOFF      = '5.4750642e-016+dpvoffp'
+NFACTOR    = 3.5653785           LNFACTOR   = -4.4344304e-007     WNFACTOR   = -4.8407192e-007
+PNFACTOR   = 6.1153765e-014      ETA0       = 0.42316678          LETA0      = '3.8346516e-009+dleta0p'
+WETA0      = '5.7423081e-009+dweta0p'
+PETA0      = '-8.2061544e-016+dpeta0p'
+ETAB       = -0.086790123        WETAB      = -7.1069136e-009     U0         = '50.946085+du0p'
+LU0        = '2.7351976e-006+dlu0p'
+WU0        = 7.7348853e-006      PU0        = -1.4963849e-012     UA         = -1.4819468e-009
+LUA        = 9.9327683e-017      WUA        = 7.6279428e-017      PUA        = -3.1975117e-023
+UB         = 2.9004244e-018      LUB        = -3.969791e-026      WUB        = -1.8333291e-026
+PUB        = -3.1183387e-033     UC         = 5.6736579e-011      LUC        = 8.3092196e-018
+WUC        = 6.5884423e-018      PUC        = -2.4700525e-024     VSAT       = 149814.81
+WVSAT      = -0.01066037         A0         = 5.2689644           LA0        = -2.7454856e-007
+WA0        = 9.1178591e-007      PA0        = 7.3611503e-014      AGS        = -2.1247419
+LAGS       = 2.045478e-006       WAGS       = 3.8310702e-007      PAGS       = -1.461343e-013
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.19802219         LKETA      = 3.2399242e-009
+WKETA      = 3.345888e-008       PKETA      = -4.9236927e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.26670647          LPCLM      = -5.2951813e-008
+WPCLM      = -3.5888083e-008     PPCLM      = 2.8488075e-014      PDIBLC1    = 0
+PDIBLC2    = -0.0043213259       LPDIBLC2   = 1.6165724e-009      WPDIBLC2   = 1.2058925e-009
+PPDIBLC2   = -2.4850238e-016     PDIBLCB    = 0                   DROUT      = 0
+PVAG       = 3                   DELTA      = 0.020306            PSCBE1     = 9.264e+008
+PSCBE2     = 1e-020              FPROUT     = 80                  PDITS      = 0.45
+PDITSD     = 0.43                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = 130                 RDW        = 130
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.5                 BETA0      = 14.31
+AGIDL      = 5.16e-008           BGIDL      = 2.3e+009            CGIDL      = 0.5
+EGIDL      = 0.53                AIGBACC    = 0.01095             BIGBACC    = 0.00456
+CIGBACC    = 0.2247              NIGBACC    = 4.046               AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.00530949          LAIGC      = -3.9914589e-011
+WAIGC      = -3.5278094e-011     PAIGC      = 6.5649235e-018      BIGC       = 0.0010044568
+WBIGC      = -6.3251531e-012     CIGC       = 1e-010              AIGSD      = 0.0042301852
+WAIGSD     = 1.066037e-011       BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.21697531
+WKT1       = -1.7767284e-008     KT1L       = 0                   KT2        = -0.03875
+UTE        = 0.19511118          LUTE       = -1.7206781e-007     WUTE       = -2.9093362e-007
+PUTE       = 3.7415551e-014      UA1        = 5.6357396e-009      LUA1       = -4.7250982e-016
+WUA1       = -5.9646131e-016     PUA1       = 4.9967438e-023      UB1        = -4.7202031e-018
+LUB1       = 8.558164e-026       WUB1       = 2.4130339e-025      PUB1       = 3.3082291e-032
+UC1        = -1.171193e-010      WUC1       = -1.72698e-020       PRT        = 0
+AT         = 328939.7            LAT        = '-0.016079877+dlatp'
+WAT        = -0.048667676        PAT        = '4.9236927e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp'
+PVSAT      = '0+dpvsatp'         LKT1       = '0+dlkt1p'          PKT1       = '0+dpkt1p'          )

.MODEL pch.19 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.20704E-09
+LL         = 4.38278E-03         WL         = 0                   LLN        = -0.84142
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.38278E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.20704E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.18663989+dvthp' LVTH0      = '2.9080881e-010+dlvthp'
+WVTH0      = '3.5534568e-009+dwvthp'
+PVTH0      = '4.2153621e-030+dpvthp'
+K1         = 0.11                K2         = 0.017990617         LK2        = '-3.8415485e-010+dlk2p'
+WK2        = -3.2229518e-009     PK2        = 2.0667531e-016      K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.17679012          WDVT2      = 7.1069136e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.12599314+dvoffp'
+LVOFF      = '-1.6743088e-009+dlvoffp'
+WVOFF      = 6.2378101e-009      PVOFF      = '-2.9871127e-016+dpvoffp'
+NFACTOR    = -1.0324447          LNFACTOR   = 2.1361762e-007      WNFACTOR   = -7.0124777e-008
+PNFACTOR   = 1.9978613e-015      ETA0       = 0.37153289          LETA0      = '1.1213492e-008+dleta0p'
+WETA0      = '3.8565958e-008+dweta0p'
+PETA0      = '-5.5113415e-015+dpeta0p'
+ETAB       = -0.0099978684       LETAB      = -1.0974143e-008     WETAB      = -1.1927658e-008
+PETAB      = 6.8891769e-016      U0         = '62.046441+du0p'    LU0        = '1.1488803e-006+dlu0p'
+WU0        = 1.2240801e-006      PU0        = -5.6594588e-013     UA         = -1.288222e-009
+LUA        = 7.1643084e-017      WUA        = 5.831227e-018       PUA        = -2.1907583e-023
+UB         = 3.2107497e-018      LUB        = -8.4045541e-026     WUB        = -1.5657505e-025
+PUB        = 1.6637362e-032      UC         = 1.227975e-010       LUC        = -1.131342e-018
+WUC        = -1.3130381e-017     PUC        = 3.4790343e-025      VSAT       = 146360.42
+LVSAT      = '0.00049365693+dlvsatp'
+WVSAT      = -0.014275929        PVSAT      = '5.1668827e-010+dpvsatp'
+A0         = -2.8139157          LA0        = 8.8055078e-007      WA0        = 3.7638612e-006
+PA0        = -3.3396973e-013     AGS        = 15.900759           LAGS       = -5.3049046e-007
+WAGS       = -3.0015432e-006     PAGS       = 3.3755558e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.25615093         LKETA      = 1.1546923e-008      WKETA      = 1.1941501e-008
+PKETA      = -1.8487106e-015     DWG        = 0                   DWB        = 0
+PCLM       = -0.30095799         LPCLM      = 2.8171355e-008      WPCLM      = 2.695154e-007
+PPCLM      = -1.5156189e-014     PDIBLC1    = 0                   PDIBLC2    = 0.01020935
+LPDIBLC2   = -4.599614e-010      WPDIBLC2   = -8.5890087e-010     PPDIBLC2   = 4.6570836e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0050713867        LAIGC      = -5.8879808e-012     WAIGC      = 3.9584839e-011
+PAIGC      = -4.1335061e-018     BIGC       = 0.0010044568        WBIGC      = -6.3251531e-012
+CIGC       = 1e-010              AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.16053258         LKT1       = '-8.066055e-009+dlkt1p'
+WKT1       = -2.2588029e-008     PKT1       = '6.8891769e-016+dpkt1p'
+KT1L       = 0                   KT2        = -0.030685557        LKT2       = -1.1524645e-009
+WKT2       = -4.3386703e-009     PKT2       = 6.2002592e-016      UTE        = -1.3393754
+LUTE       = 4.7220916e-008      WUTE       = 5.4370422e-008      PUTE       = -1.193078e-014
+UA1        = -1.913989e-010      LUA1       = 3.6022849e-016      WUA1       = 4.0084012e-016
+PUA1       = -9.2553818e-023     UB1        = -1.4806283e-018     LUB1       = -3.7737594e-025
+WUB1       = -2.8793112e-025     PUB1       = 1.0871355e-031      UC1        = -1.4080082e-010
+LUC1       = 3.3842526e-018      WUC1       = 5.4570233e-018      PUC1       = -7.8231426e-025
+PRT        = 0                   AT         = 322522.03           LAT        = '-0.015162747+dlatp'
+WAT        = -0.023855317        PAT        = '1.3778354e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.20 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = '2.16e-007-dxw'     WMAX       = '5.4e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.606405E-09
+LL         = 5.48932E-03         WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.48932E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.606405E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.19937157+dvthp' LVTH0      = '1.026165e-009+dlvthp'
+WVTH0      = '-3.9667919e-009+dwvthp'
+PVTH0      = '4.3435453e-016+dpvthp'
+K1         = 0.11                K2         = -0.10505805         LK2        = '6.72289e-009+dlk2p'
+WK2        = 3.5534568e-010      PK2        = -3.4909826e-030     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.37710017          LDVT2      = -1.1569508e-008
+WDVT2      = 3.2174409e-008      PDVT2      = -1.4478484e-015     DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '0.0082712053+dvoffp'
+LVOFF      = '-9.4291487e-009+dlvoffp'
+WVOFF      = -8.9609613e-009     PVOFF      = '5.7913937e-016+dpvoffp'
+NFACTOR    = -1.3728108          LNFACTOR   = 2.3327648e-007      WNFACTOR   = -2.4169467e-006
+PNFACTOR   = 1.375456e-013       ETA0       = 0.46955196          LETA0      = '5.5521061e-009+dleta0p'
+WETA0      = '-1.7592591e-007+dweta0p'
+PETA0      = '6.87728e-015+dpeta0p'
+ETAB       = -0.84406865         LETAB      = 3.7200117e-008      WETAB      = 4.725223e-008
+PETAB      = -2.7291943e-015     U0         = '111.52961+du0p'    LU0        = '-1.7091684e-006+dlu0p'
+WU0        = -1.880203e-005      PU0        = 5.9072216e-013      UA         = 3.2384177e-009
+LUA        = -1.8980657e-016     WUA        = -1.2495773e-015     PUA        = 5.0602302e-023
+UB         = -1.0271029e-018     LUB        = 1.6072435e-025      WUB        = 8.2208741e-025
+PUB        = -3.9888224e-032     UC         = 2.0842926e-010      LUC        = -6.0772611e-018
+WUC        = -5.4985831e-017     PUC        = 2.7653905e-024      VSAT       = 242760.78
+LVSAT      = '-0.0050742351+dlvsatp'
+WVSAT      = -0.024130807        PVSAT      = '1.0858863e-009+dpvsatp'
+A0         = -34.033358          LA0        = 2.6837233e-006      WA0        = 3.3962156e-006
+PA0        = -3.1273526e-013     AGS        = -19.343852          LAGS       = 1.5051678e-006
+WAGS       = 1.8760625e-005      PAGS       = -9.1938375e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.05584221          LKETA      = -6.4731772e-009     WKETA      = -1.5727331e-007
+PKETA      = 7.9247983e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.3000132           LPCLM      = -6.5395384e-009     WPCLM      = -5.3807101e-008
+PPCLM      = 3.5182717e-015      PDIBLC1    = 0                   PDIBLC2    = 0.00080352076
+LPDIBLC2   = 8.3300455e-011      WPDIBLC2   = 1.730163e-010       PPDIBLC2   = -1.3030636e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0049694444        WAIGC      = -3.1981111e-011     BIGC       = 0.0010044568
+WBIGC      = -6.3251531e-012     CIGC       = 1e-010              AIGSD      = 0.0042301852
+WAIGSD     = 1.066037e-011       BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.1361269
+LKT1       = '-9.4756782e-009+dlkt1p'
+WKT1       = -4.199474e-008      PKT1       = '1.8098105e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.3096266          LKT2       = 1.4958612e-008
+WKT2       = 6.780532e-008       PKT2       = -3.5468667e-015     UTE        = 1.4001831
+LUTE       = -1.1101051e-007     WUTE       = -1.4611941e-006     PUTE       = 7.5605197e-014
+UA1        = 1.8980448e-008      LUA1       = -7.4709907e-016     WUA1       = -5.8284344e-015
+PUA1       = 2.6723662e-022      UB1        = -2.6220926e-017     LUB1       = 1.0515742e-024
+WUB1       = 6.3265358e-024      PUB1       = -2.7332482e-031     UC1        = 5.9172554e-010
+LUC1       = -3.8925005e-017     WUC1       = -2.7054435e-016     PUC1       = 1.5158973e-023
+PRT        = 0                   AT         = 142323.07           LAT        = '-0.0047548161+dlatp'
+WAT        = 0.0012533748        PAT        = '-7.2392421e-011+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.21 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl'
+LMAX       = 1.21e-06            WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = -0.014756793
+LK2        = '2.5065475e-008+dlk2p'
+WK2        = 4.0781538e-009      PK2        = -5.3640117e-015     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.22962963          WDVT2      = -4.2007407e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.06612963+dvoffp'
+WVOFF      = -1.4702593e-009     NFACTOR    = -0.58518519         WNFACTOR   = 1.6802963e-007
+ETA0       = 0.40092593          WETA0      = '1.0501852e-008+dweta0p'
+ETAB       = -0.13962963         WETAB      = 4.2007407e-009      U0         = '106.16053+du0p'
+LU0        = '2.8696713e-010+dlu0p'
+WU0        = -1.388653e-006      PU0        = -6.1410967e-017     UA         = -4.1580547e-012
+LUA        = -4.2824326e-020     WUA        = -1.0404396e-016     PUA        = 9.1644058e-027
+UB         = 2.3891552e-018      LUB        = 2.1632907e-028      WUB        = -4.1671841e-026
+PUB        = -4.6294421e-035     UC         = 5.51e-011           VSAT       = 75462.963
+WVSAT      = 0.0052509259        A0         = 5.6873363           WA0        = 6.8751003e-007
+AGS        = 0.62749788          LAGS       = 1.2790654e-006      WAGS       = 9.9995551e-009
+PAGS       = -3.3067444e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.045533155
+LKETA      = 6.718767e-008       WKETA      = 3.6664953e-009      PKETA      = -1.4378161e-014
+DWG        = 0                   DWB        = 0                   PCLM       = -0.094444444
+WPCLM      = 6.3011111e-008      PDIBLC1    = 0                   PDIBLC2    = -0.00029259259
+WPDIBLC2   = 8.4014815e-011      PDIBLCB    = 0                   DROUT      = 0
+PVAG       = 3                   DELTA      = 0.020306            PSCBE1     = 9.264e+008
+PSCBE2     = 1e-020              FPROUT     = 80                  PDITS      = 0.45
+PDITSD     = 0.43                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = 130                 RDW        = 130
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.5                 BETA0      = 14.31
+AGIDL      = 5.16e-008           BGIDL      = 2.3e+009            CGIDL      = 0.5
+EGIDL      = 0.53                AIGBACC    = 0.01095             BIGBACC    = 0.00456
+CIGBACC    = 0.2247              NIGBACC    = 4.046               AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0054229481        LAIGC      = -2.1345523e-010
+WAIGC      = -1.0766026e-011     PAIGC      = 2.3619603e-018      BIGC       = 0.00095162691
+LBIGC      = 1.0709205e-013      WBIGC      = 4.9791168e-012      PBIGC      = -1.1077594e-020
+CIGC       = 1e-010              AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9000478           LPIGCD     = -4.2732697e-010
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.20838889
+WKT1       = -4.4107778e-009     KT1L       = 0                   KT2        = -0.03875
+UTE        = -0.43772222         WUTE       = -9.8927444e-008     UA1        = 7.6075824e-009
+WUA1       = -5.4663462e-016     UB1        = -9.6478094e-018     WUB1       = 6.4307565e-025
+UC1        = -1.171514e-010      PRT        = 0                   AT         = 220000
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LVSAT      = '0+dlvsatp'
+PVSAT      = '0+dpvsatp'         LVOFF      = '0+dlvoffp'         PVOFF      = '0+dpvoffp'
+LETA0      = '0+dleta0p'         PETA0      = '0+dpeta0p'         LKT1       = '0+dlkt1p'
+PKT1       = '0+dpkt1p'          LAT        = '0+dlatp'           PAT        = '0+dpatp'           )

.MODEL pch.22 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl'
+LMAX       = '1.058003e-006-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.0052531275
+LK2        = '5.0774274e-009+dlk2p'
+WK2        = -6.7969249e-010     PK2        = -6.1136628e-016     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.22962963          WDVT2      = -4.2007407e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.057150823+dvoffp'
+LVOFF      = '-8.9689919e-009+dlvoffp'
+WVOFF      = -1.8488378e-009     PVOFF      = '3.7816471e-016+dpvoffp'
+NFACTOR    = -1.2635873          LNFACTOR   = 6.776606e-007       WNFACTOR   = 2.2541983e-007
+PNFACTOR   = -5.7327463e-014     ETA0       = 0.40092593          WETA0      = '1.0501852e-008+dweta0p'
+ETAB       = -0.13962963         WETAB      = 4.2007407e-009      U0         = '127.7876+du0p'
+LU0        = '-2.1603144e-005+dlu0p'
+WU0        = -2.939227e-006      PU0        = 1.5488177e-012      UA         = 5.7822297e-010
+LUA        = -5.8178725e-016     WUA        = -1.2983118e-016     PUA        = 2.5768194e-023
+UB         = 2.4271571e-018      LUB        = -3.7743974e-026     WUB        = -1.1095048e-025
+PUB        = 6.9156619e-032      UC         = 2.6766135e-011      LUC        = 2.8302893e-017
+WUC        = 3.0033897e-018      PUC        = -3.0001067e-024     VSAT       = 78411.394
+LVSAT      = '-0.002945208+dlvsatp'
+WVSAT      = 0.0046199617        PVSAT      = '6.3027451e-010+dpvsatp'
+A0         = 5.4204654           LA0        = 2.6657922e-007      WA0        = 6.3985331e-007
+PA0        = 4.7604634e-014      AGS        = 1.1972007           LAGS       = 7.0998532e-007
+WAGS       = -6.3861713e-008     PAGS       = 4.0713086e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.041022059         LKETA      = -1.927293e-008      WKETA      = -6.3704471e-009
+PKETA      = -4.3521905e-015     DWG        = 0                   DWB        = 0
+PCLM       = -0.40569211         LPCLM      = 3.1090744e-007      WPCLM      = 1.151092e-007
+PPCLM      = -5.2041136e-014     PDIBLC1    = 0                   PDIBLC2    = -0.0025937273
+LPDIBLC2   = 2.2986193e-009      WPDIBLC2   = 2.6424899e-010      PPDIBLC2   = -1.8003716e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052451967        LAIGC      = -3.5898196e-011     WAIGC      = -9.6634099e-012
+PAIGC      = 1.260549e-018       BIGC       = 0.00095179134       LBIGC      = -5.7153706e-014
+WBIGC      = 4.9621086e-012      PBIGC      = 5.9119749e-021      CIGC       = 1e-010
+AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010      NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.1533478          LKT1       = '-5.4980921e-008+dlkt1p'
+WKT1       = -7.0608275e-009     PKT1       = '2.6471529e-015+dpkt1p'
+KT1L       = 0                   KT2        = -0.027693384        LKT2       = -1.104453e-008
+WKT2       = -2.3661158e-009     PKT2       = 2.3635294e-015      UTE        = -0.0014434543
+LUTE       = -4.3580187e-007     WUTE       = -1.5924762e-007     PUTE       = 6.0254243e-014
+UA1        = 1.0643526e-008      LUA1       = -3.0326245e-015     WUA1       = -8.3089195e-016
+PUA1       = 2.8394661e-022      UB1        = -1.2594557e-017     LUB1       = 2.9435265e-024
+WUB1       = 7.9914149e-025      PUB1       = -1.5589525e-031     UC1        = -1.171222e-010
+LUC1       = -2.9167562e-020     PRT        = 0                   AT         = 339049.85
+LAT        = '-0.11891972+dlatp' WAT        = -0.012619284        PAT        = '1.260549e-008+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LETA0      = '0+dleta0p'
+PETA0      = '0+dpeta0p'         )

.MODEL pch.23 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl'
+LMAX       = '4.340031e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.168+dvthp'      K1         = 0.11                K2         = 0.012459708
+LK2        = '2.3756308e-009+dlk2p'
+WK2        = -8.2255813e-010     PK2        = -5.5780496e-016     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.22962963          WDVT2      = -4.2007407e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.057928053+dvoffp'
+LVOFF      = '-8.6776029e-009+dlvoffp'
+WVOFF      = -1.4001099e-009     PVOFF      = '2.0993353e-016+dpvoffp'
+NFACTOR    = 1.2394827           LNFACTOR   = -2.6075763e-007     WNFACTOR   = 1.3669792e-008
+PNFACTOR   = 2.2059086e-014      ETA0       = 0.40092593          WETA0      = '1.0501852e-008+dweta0p'
+ETAB       = 0.041741675         LETAB      = -6.7997354e-008     WETAB      = -3.4612719e-008
+PETAB      = 1.4551434e-014      U0         = '93.022323+du0p'    LU0        = '-8.5694002e-006+dlu0p'
+WU0        = -1.2694295e-006     PU0        = 9.2279906e-013      UA         = -3.4515284e-010
+LUA        = -2.3560729e-016     WUA        = -1.6699447e-016     PUA        = 3.9700968e-023
+UB         = 2.2112708e-018      LUB        = 4.3193288e-026      WUB        = 1.2914559e-025
+PUB        = -2.0857055e-032     UC         = 1.2527174e-010      LUC        = -8.6275385e-018
+WUC        = -8.0780826e-018     PUC        = 1.1544137e-024      VSAT       = 71160.127
+LVSAT      = '-0.00022665785+dlvsatp'
+WVSAT      = 0.0061717329        PVSAT      = '4.8504779e-011+dpvsatp'
+A0         = 5.5434278           LA0        = 2.2047975e-007      WA0        = 8.5305074e-007
+PA0        = -3.2324555e-014     AGS        = -0.65986939         LAGS       = 1.4062137e-006
+WAGS       = 6.9624291e-008      PAGS       = -9.3317374e-015     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.13036807          LKETA      = -5.2769368e-008     WKETA      = -3.6816636e-008
+PKETA      = 7.0622958e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.21148043          LPCLM      = 7.9525193e-008      WPCLM      = -2.406971e-008
+PPCLM      = 1.379961e-016       PDIBLC1    = 0                   PDIBLC2    = 0.0020376781
+LPDIBLC2   = 5.6227351e-010      WPDIBLC2   = -1.5493438e-010     PPDIBLC2   = -2.2882421e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0051317636        LAIGC      = 6.6286728e-012      WAIGC      = 2.7553627e-012
+PAIGC      = -3.3953345e-018     BIGC       = 0.00095163889       WBIGC      = 4.9778778e-012
+CIGC       = 1e-010              AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.29395429         LKT1       = '-2.2665785e-009+dlkt1p'
+WKT1       = -1.293782e-009      PKT1       = '4.8504779e-016+dpkt1p'
+KT1L       = 0                   KT2        = -0.057152778        WKT2       = 3.9381944e-009
+UTE        = -1.1089913          LUTE       = -2.0574545e-008     WUTE       = -1.1855695e-008
+PUTE       = 4.9959922e-015      UA1        = 4.1835522e-009      LUA1       = -6.1073598e-016
+WUA1       = -2.8569321e-016     PUA1       = 7.9547838e-023      UB1        = -7.228367e-018
+LUB1       = 9.3170487e-025      WUB1       = 7.7805047e-025      PUB1       = -1.4798808e-031
+UC1        = -7.6572828e-011     LUC1       = -1.5231407e-017     WUC1       = -8.6942149e-018
+PUC1       = 3.2595211e-024      PRT        = 0                   AT         = -44993.17
+LAT        = '0.02506066+dlatp'  WAT        = 0.03135396          PAT        = '-3.8803823e-009+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp'
+WVTH0      = '0+dwvthp'          PVTH0      = '0+dpvthp'          LETA0      = '0+dleta0p'
+PETA0      = '0+dpeta0p'         )

.MODEL pch.24 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl'
+LMAX       = '2.020031e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -1.20704E-09
+LL         = 4.38278E-03         WL         = 0                   LLN        = -0.84142
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 4.38278E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-1.20704E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17203222+dvthp' LVTH0      = '5.7623227e-010+dlvthp'
+WVTH0      = '4.2741548e-010+dwvthp'
+PVTH0      = '-6.1080621e-017+dpvthp'
+K1         = 0.11                K2         = 0.022017525         LK2        = '1.0097528e-009+dlk2p'
+WK2        = -4.0847101e-009     PK2        = -9.1620931e-017     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.22962963          WDVT2      = -4.2007407e-009
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 3e-007              DVTP1      = 3                   LPE0       = 2.3e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.093124111+dvoffp'
+LVOFF      = '-3.6478434e-009+dlvoffp'
+WVOFF      = -7.9616152e-010     PVOFF      = '1.2362514e-016+dpvoffp'
+NFACTOR    = -3.8762818          LNFACTOR   = 4.7032042e-007      WNFACTOR   = 5.3845637e-007
+PNFACTOR   = -5.2936538e-014     ETA0       = 0.56924919          LETA0      = '-2.4054556e-008+dleta0p'
+WETA0      = '-3.7453307e-009+dweta0p'
+PETA0      = '2.0360207e-015+dpeta0p'
+ETAB       = -0.59285065         LETAB      = 2.2690268e-008      WETAB      = 1.1280284e-007
+PETAB      = -6.5152662e-015     U0         = '39.14983+du0p'     LU0        = '-8.7064926e-007+dlu0p'
+WU0        = 6.1239547e-006      PU0        = -1.3376656e-013     UA         = -1.9749347e-009
+LUA        = -2.7002136e-018     WUA        = 1.5278774e-016      PUA        = -5.9981169e-024
+UB         = 2.9171175e-018      LUB        = -5.767708e-026      WUB        = -9.3737748e-026
+PUB        = 1.0994512e-032      UC         = 2.8219346e-011      LUC        = 5.2419185e-018
+WUC        = 7.1093441e-018      PUC        = -1.0159743e-024     VSAT       = 28586.103
+LVSAT      = '0.0058574638+dlvsatp'
+WVSAT      = 0.010927775         PVSAT      = '-6.3116641e-010+dpvsatp'
+A0         = 13.186804           LA0        = -8.7181147e-007     WA0        = 3.397071e-007
+PA0        = 4.1035793e-014      AGS        = -6.1481365          LAGS       = 2.190525e-006
+WAGS       = 1.7169204e-006      PAGS       = -2.4474172e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.25258086         LKETA      = 1.9566766e-009      WKETA      = 1.1177504e-008
+PKETA      = 2.0360207e-016      DWG        = 0                   DWB        = 0
+PCLM       = 1.1929164           LPCLM      = -6.0728778e-008     WPCLM      = -5.0173721e-008
+PPCLM      = 3.8684393e-015      PDIBLC1    = 0                   PDIBLC2    = 0.0086666506
+LPDIBLC2   = -3.850524e-010      WPDIBLC2   = -5.2876329e-010     PPDIBLC2   = 3.054031e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0054144288        LAIGC      = -3.3766134e-011     WAIGC      = -3.3826168e-011
+PAIGC      = 1.8324186e-018      BIGC       = 0.00095163889       WBIGC      = 4.9778778e-012
+CIGC       = 1e-010              AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop'
+CGDO       = 'cgop'              CGBO       = 0                   CGDL       = 'cglp'
+CGSL       = 'cglp'              CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp'               CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 2.175
+VOFFCV     = -0.03885            KT1        = -0.24926869         LKT1       = '-8.6524596e-009+dlkt1p'
+WKT1       = -3.5985026e-009     PKT1       = '8.1440827e-016+dpkt1p'
+KT1L       = 0                   KT2        = -0.080014594        LKT2       = 3.2671113e-009
+WKT2       = 6.2177436e-009      PKT2       = -3.2576331e-016     UTE        = -0.75919797
+LUTE       = -7.0562424e-008     WUTE       = -6.9787556e-008     PUTE       = 1.3274855e-014
+UA1        = 1.2274644e-009      LUA1       = -1.8829063e-016     WUA1       = 9.7203387e-017
+PUA1       = 2.4829272e-023      UB1        = -2.076584e-018      LUB1       = 1.9547953e-025
+WUB1       = -1.6039661e-025     PUB1       = -1.3877517e-032     UC1        = -1.7939215e-010
+LUC1       = -5.3781678e-019     WUC1       = 1.3715568e-017      PUC1       = 5.7008579e-026
+PRT        = 0                   AT         = 171446.27           LAT        = '-0.0058700297+dlatp'
+WAT        = 0.0084748955        PAT        = '-6.1080621e-010+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch.25 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl' WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp'              TOXM       = 2.13e-009           DTOX       = 6.4e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = -8.606405E-09
+LL         = 5.48932E-03         WL         = 0                   LLN        = -0.7901
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 5.48932E-03         WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '-8.606405E-09+ddlcp'
+DWC        = 0                   XL         = '-4.5E-08+dxl'      XW         = '0.01e-6+dxw'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.31535806+dvthp' LVTH0      = '8.854446e-009+dlvthp'
+WVTH0      = '2.0854317e-008+dwvthp'
+PVTH0      = '-1.2408976e-015+dpvthp'
+K1         = 0.11                K2         = -0.094206955        LK2        = '7.7226463e-009+dlk2p'
+WK2        = -1.9667883e-009     PK2        = -2.1394786e-016     K3         = -3.2
+K3B        = -0.649              W0         = 5e-008              DVT0       = 28
+DVT1       = 2.23                DVT2       = 0.68555271          LDVT2      = -2.6333205e-008
+WDVT2      = -3.3834435e-008     PDVT2      = 1.7115829e-015      DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 3e-007
+DVTP1      = 3                   LPE0       = 2.3e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.044730559+dvoffp'
+LVOFF      = '-6.4429582e-009+dlvoffp'
+WVOFF      = 2.3814163e-009      PVOFF      = '-5.9905401e-017+dpvoffp'
+NFACTOR    = -23.016868          LNFACTOR   = 1.5758424e-006      WNFACTOR   = 2.2148815e-006
+PNFACTOR   = -1.497635e-013      ETA0       = -1.1402018          LETA0      = '7.4679914e-008+dleta0p'
+WETA0      = '1.6856139e-007+dweta0p'
+PETA0      = '-7.9160709e-015+dpeta0p'
+ETAB       = -0.51940743         LETAB      = 1.8448334e-008      WETAB      = -2.222527e-008
+PETAB      = 1.2836872e-015      U0         = '-11.987906+du0p'   LU0        = '2.0829641e-006+dlu0p'
+WU0        = 7.630718e-006       PU0        = -2.2079419e-013     UA         = -3.6221842e-009
+LUA        = 9.2441623e-017      WUA        = 2.1859153e-016      PUA        = -9.7988121e-024
+UB         = 2.7991424e-018      LUB        = -5.0863077e-026     WUB        = 3.2709013e-027
+PUB        = 5.3914861e-033      UC         = 2.2098382e-010      LUC        = -5.8917717e-018
+WUC        = -5.7672506e-017     PUC        = 2.7256958e-024      VSAT       = 130000
+A0         = -32.486913          LA0        = 1.7662111e-006      WA0        = 3.0652764e-006
+PA0        = -1.1638764e-013     AGS        = 139.64474           LAGS       = -6.2301798e-006
+WAGS       = -1.5262933e-005     PAGS       = 7.3598064e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -1.0247339          LKETA      = 4.6554692e-008      WKETA      = 7.396998e-008
+PKETA      = -3.4231658e-015     DWG        = 0                   DWB        = 0
+PCLM       = -0.19818775         LPCLM      = 1.9618615e-008      WPCLM      = 5.2807901e-008
+PPCLM      = -2.0795732e-015     PDIBLC1    = 0                   PDIBLC2    = 0.0012312013
+LPDIBLC2   = 4.4404273e-011      WPDIBLC2   = 8.1492658e-011      PPDIBLC2   = -4.706853e-018
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 3
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 80                  PDITS      = 0.45                PDITSD     = 0.43
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = 130                 RDW        = 130                 PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.5                 BETA0      = 14.31               AGIDL      = 5.16e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0048298148        WAIGC      = -2.1003704e-012     BIGC       = 0.00095163889
+WBIGC      = 4.9778778e-012      CIGC       = 1e-010              AIGSD      = 0.0041916667
+WAIGSD     = 1.8903333e-011      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp'             XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop'              CGDO       = 'cgop'              CGBO       = 0
+CGDL       = 'cglp'              CGSL       = 'cglp'              CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp'               CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 2.175               VOFFCV     = -0.03885            KT1        = -0.28450544
+LKT1       = '-6.6172553e-009+dlkt1p'
+WKT1       = -1.0241734e-008     PKT1       = '1.198108e-015+dpkt1p'
+KT1L       = 0                   KT2        = 0.03197432          LKT2       = -3.2011444e-009
+WKT2       = -5.297278e-009      PKT2       = 3.3932131e-016      UTE        = -10.29286
+LUTE       = 4.8008285e-007      WUTE       = 1.0411172e-006      PUTE       = -5.0888783e-014
+UA1        = -2.0406326e-008     LUA1       = 1.0612338e-015      WUA1       = 2.6003353e-015
+PUA1       = -1.1974662e-022     UB1        = 9.0489777e-018      LUB1       = -4.4711066e-025
+WUB1       = -1.2212236e-024     PUB1       = 4.739373e-032       UC1        = -1.283473e-009
+LUC1       = 6.3231685e-017      WUC1       = 1.3074814e-016      PUC1       = -6.7025586e-024
+PRT        = 0                   AT         = 175304.18           LAT        = '-0.0060928548+dlatp'
+WAT        = -0.0058045821       PAT        = '2.1394786e-010+dpatp'
+JSS        = 1.5E-07             JSD        = 1.5E-07             JSWS       = 7.00E-13
+JSWD       = 7.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp'               CJD        = 'cjp'               MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp'             CJSWD      = 'cjswp'             MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp'            CJSWGD     = 'cjswgp'            MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.39E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp'
+PVSAT      = '0+dpvsatp'         )

.ENDL MOS

*
***************************************************************
*                                                             *
*               1.05V HIGH VT DEVICE LIB                       *
*                                                             *
***************************************************************
.LIB MOS_hvt

**********************************************************************************************
*                                                                                            *
*                               1.05V High-VT NMOS DEVICE MODELS                              *
*                                                                                            *
**********************************************************************************************
.MODEL nch_hvt.1 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn_hvt'          TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.145+dvthn_hvt'   K1         = 0.158               K2         = 0.04777
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.1068             NFACTOR    = 0.5304
+ETA0       = '0.265+deta0n_hvt'  ETAB       = -0.11               U0         = 316.3036
+UA         = -8.828316e-010      UB         = 2.194377e-018       UC         = 2.2e-010
+VSAT       = 109346.2            A0         = 4.06246             AGS        = 1.3807737
+LAGS       = -3.1502289e-009     WAGS       = -2.8382707e-006     PAGS       = 2.8351682e-012
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.085              DWG        = 0
+DWB        = 0                   PCLM       = 0.5                 PDIBLC1    = 0.0001
+PDIBLC2    = 0.0001              PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0099249693        LAIGC      = -2.2472335e-010
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2904006          KT1L       = 0
+KT2        = -0.026              UTE        = -2.387843           UA1        = 1.068855e-009
+UB1        = -3.148072e-018      UC1        = -2e-010             PRT        = 0
+AT         = 200000              JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 3.5E-13             JSWD       = 3.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.6
+PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.19E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn_hvt'      WVTH0      = '0+dwvthn_hvt'      PVTH0      = '0+dpvthn_hvt'
+LVOFF      = '0+dlvoffn_hvt'     WVOFF      = '0+dwvoffn_hvt'     WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'     LAT        = '0+dlatn_hvt'
+PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.2 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.145+dvthn_hvt'   K1         = 0.158               K2         = 0.04777
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.097922757        LVOFF      = '-8.8675389e-009+dlvoffn_hvt'
+NFACTOR    = 0.26643045          LNFACTOR   = 2.63681e-007        ETA0       = '0.265+deta0n_hvt'
+ETAB       = -0.11               U0         = 334.12177           LU0        = -1.7798694e-005
+UA         = -6.5230327e-010     LUA        = -2.3027634e-016     UB         = 2.1439022e-018
+LUB        = 5.0419671e-026      UC         = 2.2901219e-010      LUC        = -9.0023339e-018
+VSAT       = 109346.2            A0         = 4.1321422           LA0        = -6.9606046e-008
+AGS        = 1.2575386           LAGS       = 1.199501e-007       A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.085              DWG        = 0                   DWB        = 0
+PCLM       = 0.34462993          LPCLM      = 1.5520024e-007      PDIBLC1    = 0.0001
+PDIBLC2    = -0.0011075066       LPDIBLC2   = 1.2061867e-009      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.25                PDITSD     = 0.3                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.2724
+BETA0      = 10.4                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0097
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2904006          KT1L       = 0
+KT2        = -0.026              UTE        = -3.0934118          LUTE       = 7.0479752e-007
+UA1        = 3.4432218e-010      LUA1       = 7.2374083e-016      UB1        = -3.6607722e-018
+LUB1       = 5.1213977e-025      UC1        = -2e-010             PRT        = 0
+AT         = 242056.86           LAT        = '-0.042010891+dlatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthn_hvt'
+WVTH0      = '0+dwvthn_hvt'      PVTH0      = '0+dpvthn_hvt'      WVOFF      = '0+dwvoffn_hvt'
+WETA0      = '0+dweta0n_hvt'     LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'
+PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.3 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1536237+dvthn_hvt'
+LVTH0      = '-3.2330854e-009+dlvthn_hvt'
+K1         = 0.158               K2         = 0.049476261         LK2        = -6.3968904e-010
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.10012419         LVOFF      = '-8.0422076e-009+dlvoffn_hvt'
+NFACTOR    = 1.2591131           LNFACTOR   = -1.0848258e-007     ETA0       = '0.265+deta0n_hvt'
+ETAB       = -0.11               U0         = 309.22045           LU0        = -8.4630168e-006
+UA         = -1.1914191e-009     LUA        = -2.8158096e-017     UB         = 2.3759516e-018
+LUB        = -3.6577281e-026     UC         = 2.3579894e-010      LUC        = -1.1546734e-017
+VSAT       = 109346.2            A0         = 3.7951155           LA0        = 5.6747577e-008
+AGS        = 2.2106156           LAGS       = -2.3736505e-007     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.12195872         LKETA      = 1.385608e-008       DWG        = 0
+DWB        = 0                   PCLM       = 0.88536842          LPCLM      = -4.7526356e-008
+PDIBLC1    = 0.0001              PDIBLC2    = 0.0021713817        LPDIBLC2   = -2.3091158e-011
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097              BIGC       = 0.0016              CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'          CGBO       = 0
+CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.06307            KT1        = -0.2904006
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.1975884
+LUTE       = -5.9597311e-009     UA1        = 2.8686298e-009      LUA1       = -2.226395e-016
+UB1        = -2.8950278e-018     LUB1       = 2.2505692e-025      UC1        = -2e-010
+PRT        = 0                   AT         = 179278.3            LAT        = '-0.018474774+dlatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthn_hvt'
+PVTH0      = '0+dpvthn_hvt'      WVOFF      = '0+dwvoffn_hvt'     WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'     PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.4 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.2070400E-09      LL         = 4.3827800E-03
+WL         = 0                   LLN        = -0.84142000         WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.3827800E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.2070400E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.12633397+dvthn_hvt'
+LVTH0      = '6.6680813e-010+dlvthn_hvt'
+WVTH0      = '-7.3981952e-008+dwvthn_hvt'
+PVTH0      = '1.0572527e-014+dpvthn_hvt'
+K1         = 0.158               K2         = 0.034859469         LK2        = 1.4491528e-009
+WK2        = -3.0825901e-008     PK2        = 4.4052247e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.15260141         LVOFF      = '-5.4284443e-010+dlvoffn_hvt'
+NFACTOR    = -0.31059987         LNFACTOR   = 1.158404e-007       WNFACTOR   = 7.1494635e-011
+PNFACTOR   = -1.095382e-017      ETA0       = '0.26592479+deta0n_hvt'
+LETA0      = -1.3215831e-010     WETA0      = '-8.3229639e-007+dweta0n_hvt'
+PETA0      = 1.189409e-013       ETAB       = -0.11               U0         = 246.53853
+LU0        = 4.9466782e-007      WU0        = 6.288458e-005       PU0        = -8.9866435e-012
+UA         = -1.9468911e-009     LUA        = 7.9804143e-017      WUA        = 6.634773e-016
+PUA        = -9.4815992e-023     UB         = 2.5852375e-018      LUB        = -6.6485696e-026
+WUB        = -5.3019867e-025     PUB        = 7.576947e-032       UC         = 1.4489305e-010
+LUC        = 1.4443539e-018      VSAT       = 109359.58           LVSAT      = '-1.9126734e-006+dlvsatn_hvt'
+WVSAT      = -0.012045487        PVSAT      = '1.7213832e-009+dpvsatn_hvt'
+A0         = 4.914627            LA0        = -1.0323844e-007     WA0        = 8.7109452e-006
+PA0        = -1.2448535e-012     AGS        = 0.88820557          LAGS       = -4.8383387e-008
+WAGS       = -3.0209273e-005     PAGS       = 4.3171139e-012      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.0091273402       LKETA      = -2.2683142e-009     DWG        = 0
+DWB        = 0                   PCLM       = 0.72359396          LPCLM      = -2.4407653e-008
+WPCLM      = 6.1651768e-007      PPCLM      = -8.8104474e-014     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0020098014        LPDIBLC2   = -1.957901e-016      WPDIBLC2   = -1.2330317e-012
+PPDIBLC2   = 1.7620874e-019      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097              BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.2904006          LKT1       = -5.8737029e-016     WKT1       = -3.6990951e-012
+PKT1       = 5.2862621e-019      KT1L       = 0                   KT2        = -0.026
+UTE        = -1.744726           LUTE       = 7.2230061e-008      WUTE       = 2.1161853e-010
+PUTE       = -3.070113e-017      UA1        = 2.5456014e-010      LUA1       = 1.5092935e-016
+WUA1       = -1.9101421e-018     PUA1       = 2.7201258e-025      UB1        = -6.6861214e-019
+LUB1       = -9.3113465e-026     WUB1       = 1.5914006e-027      PUB1       = -2.2682993e-034
+UC1        = -2e-010             PRT        = 0                   AT         = 50000
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVOFF      = '0+dwvoffn_hvt'
+LAT        = '0+dlatn_hvt'       PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.5 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.6064050E-09      LL         = 5.4893200E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.4893200E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.6064050E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.066907948+dvthn_hvt'
+LVTH0      = '4.0991423e-009+dlvthn_hvt'
+WVTH0      = '4.9376241e-007+dwvthn_hvt'
+PVTH0      = '-2.2219308e-014+dpvthn_hvt'
+K1         = 0.158               K2         = 0.042135548         LK2        = 1.0289003e-009
+WK2        = 2.0573434e-007      PK2        = -9.2580451e-015     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.08792941         LVOFF      = '-4.2781766e-009+dlvoffn_hvt'
+NFACTOR    = 0.22070198          LNFACTOR   = 8.5153411e-008      WNFACTOR   = -5.3490927e-010
+PNFACTOR   = 2.4070917e-017      ETA0       = '-0.040981645+deta0n_hvt'
+LETA0      = 1.7594174e-008      WETA0      = '5.5548271e-006+dweta0n_hvt'
+PETA0      = -2.4996722e-013     ETAB       = -0.11               U0         = 337.2967
+LU0        = -4.7473517e-006     WU0        = -0.00041969804      PU0        = 1.8886412e-011
+UA         = -1.192661e-009      LUA        = 3.6241244e-017      WUA        = -4.4281518e-015
+PUA        = 1.9926683e-022      UB         = 2.2035186e-018      LUB        = -4.4438336e-026
+WUB        = 3.5386306e-024      PUB        = -1.5923838e-031     UC         = 3.6248354e-010
+LUC        = -1.1123259e-017     VSAT       = 89314.954           LVSAT      = '0.0011558271+dlvsatn_hvt'
+WVSAT      = 0.080392749         PVSAT      = '-3.6176737e-009+dpvsatn_hvt'
+A0         = 7.7026417           LA0        = -2.6426888e-007     WA0        = -5.8137643e-005
+PA0        = 2.6161939e-012      AGS        = -17.407163          LAGS       = 1.0083223e-006
+WAGS       = 0.00020161965       PAGS       = -9.0728842e-012     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.010151038         LKETA      = -3.3817967e-009     DWG        = 0
+DWB        = 0                   PCLM       = 0.65728903          LPCLM      = -2.0578006e-008
+WPCLM      = -4.1146867e-006     PPCLM      = 1.851609e-013       PDIBLC1    = 0.0001
+PDIBLC2    = 0.0020443571        LPDIBLC2   = -1.9960709e-012     WPDIBLC2   = 8.2293734e-012
+PPDIBLC2   = -3.703218e-019      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097              BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.29040063         LKT1       = 1.2344225e-015      WKT1       = 2.468812e-011
+PKT1       = -1.1109654e-018     KT1L       = 0                   KT2        = -0.026
+UTE        = -0.49416319         LUTE       = -7.2419452e-014     WUTE       = -1.4483697e-009
+PUTE       = 6.5176638e-017      UA1        = 2.8676779e-009      LUA1       = 6.336702e-022
+WUA1       = 1.2673235e-017      PUA1       = -5.7029558e-025     UB1        = -2.2807313e-018
+LUB1       = -5.2874429e-031     WUB1       = -1.0574745e-026     PUB1       = 4.7586352e-034
+UC1        = -2e-010             PRT        = 0                   AT         = 50000
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVOFF      = '0+dwvoffn_hvt'
+LAT        = '0+dlatn_hvt'       PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.6 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn_hvt'          TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.14497982+dvthn_hvt'
+WVTH0      = '1.815552e-010+dwvthn_hvt'
+K1         = 0.158               K2         = 0.04777             K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10701266         WVOFF      = '1.913512e-009+dwvoffn_hvt'
+NFACTOR    = 0.47745126          WNFACTOR   = 4.7643277e-007      ETA0       = '0.26943457+deta0n_hvt'
+WETA0      = '-3.9902242e-008+dweta0n_hvt'
+ETAB       = -0.11               U0         = 316.84391           WU0        = -4.8616892e-006
+UA         = -8.8651973e-010     WUA        = 3.3185797e-017      UB         = 2.1870902e-018
+WUB        = 6.5566366e-026      UC         = 2.2166296e-010      WUC        = -1.4963341e-017
+VSAT       = 109346.2            A0         = 4.0218462           WA0        = 3.6544269e-007
+AGS        = 1.0682572           LAGS       = 3.0564115e-007      WAGS       = -2.6247052e-008
+PAGS       = 5.6663375e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.084445679
+WKETA      = -4.9877802e-009     DWG        = 0                   DWB        = 0
+PCLM       = 0.46230617          WPCLM      = 3.3916906e-007      PDIBLC1    = 0.0001
+PDIBLC2    = -0.00033237037      WPDIBLC2   = 3.8904686e-009      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.25                PDITSD     = 0.3                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.2724
+BETA0      = 10.4                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0099360557
+LAIGC      = -2.2472335e-010     WAIGC      = -9.9755605e-011     PAIGC      = 4.6142443e-030
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2904006          KT1L       = 0
+KT2        = -0.026              UTE        = -2.4563397          WUTE       = 6.1633302e-007
+UA1        = 9.8225399e-010      WUA1       = 7.7923592e-016      UB1        = -3.1577369e-018
+WUB1       = 8.6964941e-026      UC1        = -2e-010             PRT        = 0
+AT         = 197782.72           WAT        = 0.019951121         JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 3.5E-13             JSWD       = 3.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn_hvt'
+CJD        = 'cjn_hvt'           MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'
+CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.6                 PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'
+CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.19E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn_hvt'      PVTH0      = '0+dpvthn_hvt'
+LVOFF      = '0+dlvoffn_hvt'     LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'
+LAT        = '0+dlatn_hvt'       PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.7 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1449677+dvthn_hvt'
+LVTH0      = '1.210951e-011+dlvthn_hvt'
+WVTH0      = '2.9063581e-010+dwvthn_hvt'
+PVTH0      = '-1.0896137e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.047836609         LK2        = -6.6535768e-011
+WK2        = -5.9934398e-010     PK2        = 5.9868884e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.097798564        LVOFF      = '-9.2040236e-009+dlvoffn_hvt'
+WVOFF      = '-1.1174904e-009+dwvoffn_hvt'
+PVOFF      = 3.0276892e-015      NFACTOR    = 0.18166943          LNFACTOR   = 2.9545851e-007
+WNFACTOR   = 7.626797e-007       PNFACTOR   = -2.8593403e-013     ETA0       = '0.26943457+deta0n_hvt'
+WETA0      = '-3.9902242e-008+dweta0n_hvt'
+ETAB       = -0.11               U0         = 332.54571           LU0        = -1.568464e-005
+WU0        = 1.4181387e-005      PU0        = -1.902226e-011      UA         = -6.7176039e-010
+LUA        = -2.1452459e-016     WUA        = 1.7507515e-016      PUA        = -1.4173425e-022
+UB         = 2.1390807e-018      LUB        = 4.795705e-026       WUB        = 4.3383447e-026
+PUB        = 2.2158671e-032      UC         = 2.2967602e-010      LUC        = -8.0042974e-018
+WUC        = -5.973181e-018      PUC        = -8.9803326e-024     VSAT       = 109346.2
+A0         = 4.0859117           LA0        = -6.3995483e-008     WA0        = 4.1598177e-007
+PA0        = -5.0483838e-014     AGS        = 1.27004             LAGS       = 1.0407892e-007
+WAGS       = -1.1248679e-007     PAGS       = 1.4280884e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.084778722        LKETA      = 3.3267884e-010      WKETA      = -1.9910603e-009
+PKETA      = -2.9934442e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.28428919          LPCLM      = 1.778224e-007       WPCLM      = 5.4294601e-007
+PPCLM      = -2.0355421e-013     PDIBLC1    = 0.0001              PDIBLC2    = -0.0017403548
+LPDIBLC2   = 1.4064454e-009      WPDIBLC2   = 5.6943681e-009      PPDIBLC2   = -1.8019277e-015
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097110864        WAIGC      = -9.9755605e-011     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.2904006          KT1L       = 0                   KT2        = -0.026
+UTE        = -3.2021639          LUTE       = 7.4500894e-007      WUTE       = 9.7855135e-007
+PUTE       = -3.6182239e-013     UA1        = 2.0070942e-010      LUA1       = 7.8069026e-016
+WUA1       = 1.2922276e-015      PUA1       = -5.1243095e-022     UB1        = -3.6762439e-018
+LUB1       = 5.1794023e-025      WUB1       = 1.3921455e-025      PUB1       = -5.2192496e-032
+UC1        = -1.9600349e-010     LUC1       = -3.9921461e-018     WUC1       = -3.5960639e-017
+PUC1       = 3.592133e-023       PRT        = 0                   AT         = 238507.41
+LAT        = '-0.040680176+dlatn_hvt'
+WAT        = 0.031938001         PAT        = '-1.1973777e-008+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.8 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1542383+dvthn_hvt'
+LVTH0      = '-3.4635029e-009+dlvthn_hvt'
+WVTH0      = '-5.5302534e-009+dwvthn_hvt'
+PVTH0      = '2.0733301e-015+dpvthn_hvt'
+K1         = 0.158               K2         = 0.049092235         LK2        = -5.3727888e-010
+WK2        = 3.4554464e-009      PK2        = -9.2148007e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10086854         LVOFF      = '-8.0530692e-009+dlvoffn_hvt'
+WVOFF      = '6.6974474e-009+dwvoffn_hvt'
+PVOFF      = 9.7815109e-017      NFACTOR    = 1.2643234           LNFACTOR   = -1.1043592e-007
+WNFACTOR   = -4.6884904e-008     PNFACTOR   = 1.7577324e-014      ETA0       = '0.26943457+deta0n_hvt'
+WETA0      = '-3.9902242e-008+dweta0n_hvt'
+ETAB       = -0.11               U0         = 315.7517            LU0        = -9.3884504e-006
+WU0        = -5.8768455e-005     PU0        = 8.3271389e-012      UA         = -1.1513099e-009
+LUA        = -3.4738151e-017     WUA        = -3.6090294e-016     PUA        = 5.9207628e-023
+UB         = 2.3539488e-018      LUB        = -3.2598479e-026     WUB        = 1.9798064e-025
+PUB        = -3.5800883e-032     UC         = 2.3926141e-010      LUC        = -1.1597925e-017
+WUC        = -3.1155627e-017     PUC        = 4.6074003e-025      VSAT       = 109346.2
+A0         = 3.7089301           LA0        = 7.7337543e-008      WA0        = 7.7549838e-007
+PA0        = -1.852691e-013      AGS        = 2.1576508           LAGS       = -2.2869252e-007
+WAGS       = 4.7657105e-007      PAGS       = -7.8033005e-014     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.12085004         LKETA      = 1.3856065e-008      WKETA      = -9.9755605e-009
+PKETA      = 5.5237424e-031      DWG        = 0                   DWB        = 0
+PCLM       = 0.88176257          LPCLM      = -4.6174497e-008     WPCLM      = 3.2444153e-008
+PPCLM      = -1.2163537e-014     PDIBLC1    = 0.0001              PDIBLC2    = 0.0020112276
+LPDIBLC2   = -4.875339e-014      WPDIBLC2   = 1.4410659e-009      PPDIBLC2   = -2.0733532e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097110864        WAIGC      = -9.9755605e-011     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.28971766         LKT1       = -2.5603894e-010     WKT1       = -6.1450947e-009
+PKT1       = 2.3038384e-015      KT1L       = 0                   KT2        = -0.026
+UTE        = -1.1923462          LUTE       = -8.4855761e-009     WUTE       = -4.716998e-008
+PUTE       = 2.2727615e-014      UA1        = 2.903148e-009       LUA1       = -2.324726e-016
+WUA1       = -3.1060088e-016     PUA1       = 8.8480516e-023      UB1        = -2.9146128e-018
+LUB1       = 2.3239945e-025      WUB1       = 1.7623136e-025      PUB1       = -6.6070351e-032
+UC1        = -2.0528605e-010     LUC1       = -5.1204716e-019     WUC1       = 4.7563911e-017
+PUC1       = 4.6074003e-024      PRT        = 0                   AT         = 179278.24
+LAT        = '-0.018474753+dlatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'     PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.9 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.2070400E-09      LL         = 4.3827800E-03
+WL         = 0                   LLN        = -0.84142000         WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.3827800E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.2070400E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.11606133+dvthn_hvt'
+LVTH0      = '1.9922496e-009+dlvthn_hvt'
+WVTH0      = '1.845127e-008+dwvthn_hvt'
+PVTH0      = '-1.353795e-015+dpvthn_hvt'
+K1         = 0.158               K2         = 0.031991805         LK2        = 1.9064906e-009
+WK2        = -5.0226536e-009     PK2        = 2.9009893e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.15352709         LVOFF      = '-5.2779918e-010+dlvoffn_hvt'
+WVOFF      = '8.3292413e-009+dwvoffn_hvt'
+PVOFF      = -1.353795e-016      NFACTOR    = -0.33343688         LNFACTOR   = 1.1789504e-007
+WNFACTOR   = 2.0555893e-007      PNFACTOR   = -1.8498642e-014     ETA0       = '0.16770924+deta0n_hvt'
+LETA0      = 1.4537251e-008      WETA0      = '5.1447104e-008+dweta0n_hvt'
+PETA0      = -1.3054452e-014     ETAB       = -0.11               U0         = 254.38735
+LU0        = -6.1906075e-007     WU0        = -7.7390595e-006     PU0        = 1.0346862e-012
+UA         = -1.8650004e-009     LUA        = 6.725314e-017       WUA        = -7.3375231e-017
+PUA        = 1.8117935e-023      UB         = 2.5140038e-018      LUB        = -5.5471438e-026
+WUB        = 1.1076254e-025      PUB        = -2.3336815e-032     UC         = 1.4635033e-010
+LUC        = 1.6797094e-018      WUC        = -1.3112676e-017     PUC        = -2.1177222e-024
+VSAT       = 107873.97           LVSAT      = '0.00021039172+dlvsatn_hvt'
+WVSAT      = 0.0013220619        PVSAT      = '-1.8893176e-010+dpvsatn_hvt'
+A0         = 6.299496            LA0        = -2.928722e-007      WA0        = -3.7501061e-006
+PA0        = 4.61471e-013        AGS        = -2.8178873          LAGS       = 4.8234622e-007
+WAGS       = 3.1381508e-006      PAGS       = -4.5839112e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.0066349744       LKETA      = -2.4660563e-009     WKETA      = -2.2426138e-008
+PKETA      = 1.7792734e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.80945555          LPCLM      = -3.5841325e-008     WPCLM      = -1.5606489e-007
+PPCLM      = 1.4775705e-014      PDIBLC1    = 0.0001              PDIBLC2    = 0.0020107358
+LPDIBLC2   = 2.1536669e-014      WPDIBLC2   = -9.6407169e-012     PPDIBLC2   = -1.9339929e-020
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097110864        WAIGC      = -9.9755605e-011     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.29278818         LKT1       = 1.8276009e-010      WKT1       = 2.1479816e-008
+PKT1       = -1.643952e-015      KT1L       = 0                   KT2        = -0.026
+UTE        = -1.7655656          LUTE       = 7.3431437e-008      WUTE       = 1.8772632e-007
+PUTE       = -1.0840688e-014     UA1        = 1.9677405e-010      LUA1       = 1.5428691e-016
+WUA1       = 5.1804902e-016      PUA1       = -2.9939273e-023     UB1        = -6.1505217e-019
+LUB1       = -9.6223627e-026     WUB1       = -4.8034126e-025     PUB1       = 2.7758406e-032
+UC1        = -2.0962115e-010     LUC1       = 1.0746793e-019      WUC1       = 8.6571102e-017
+PUC1       = -9.6699643e-025     PRT        = 0                   AT         = 50000
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LAT        = '0+dlatn_hvt'
+PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.10 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.6064050E-09      LL         = 5.4893200E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.4893200E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.6064050E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.1270294+dvthn_hvt'
+LVTH0      = '1.3587549e-009+dlvthn_hvt'
+WVTH0      = '-4.7210389e-008+dwvthn_hvt'
+PVTH0      = '2.4386977e-015+dpvthn_hvt'
+K1         = 0.158               K2         = 0.070865555         LK2        = -3.3878329e-010
+WK2        = -5.2778261e-008     PK2        = 3.0483721e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.08093027         LVOFF      = '-4.7208534e-009+dlvoffn_hvt'
+WVOFF      = '-6.2978258e-008+dwvoffn_hvt'
+PVOFF      = 3.9832062e-015      NFACTOR    = 0.53918283          LNFACTOR   = 6.7494184e-008
+WNFACTOR   = -2.8662256e-006     PNFACTOR   = 1.589218e-013       ETA0       = '0.6329083+deta0n_hvt'
+LETA0      = -1.2331762e-008     WETA0      = '-5.0883463e-007+dweta0n_hvt'
+PETA0      = 1.9306357e-014      ETAB       = -0.11               U0         = 298.63357
+LU0        = -3.1746384e-006     WU0        = -7.1807161e-005     PU0        = 4.735138e-012
+UA         = -1.5291147e-009     LUA        = 4.7853022e-017      WUA        = -1.4007408e-015
+PUA        = 9.4784049e-023      UB         = 2.5276855e-018      LUB        = -5.6261672e-026
+WUB        = 6.2177625e-025      PUB        = -5.2851996e-032     UC         = 3.7763517e-010
+LUC        = -1.1678864e-017     WUC        = -1.363344e-016      PUC        = 4.9993302e-024
+VSAT       = 97019.237           LVSAT      = '0.00083734051+dlvsatn_hvt'
+WVSAT      = 0.011069613         PVSAT      = '-7.5193178e-010+dpvsatn_hvt'
+A0         = -0.62961745         LA0        = 1.0734023e-007      WA0        = 1.6836025e-005
+PA0        = -7.275448e-013      AGS        = 5.5371672           LAGS       = -2.2585553e-010
+WAGS       = -4.8334301e-006     PAGS       = 2.0322481e-015      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.0098454381        LKETA      = -3.4179336e-009     WKETA      = 2.7497896e-009
+PKETA      = 3.2515969e-016      DWG        = 0                   DWB        = 0
+PCLM       = 0.18891358          WPCLM      = 9.9755605e-008      PDIBLC1    = 0.0001
+PDIBLC2    = 0.0020502907        LPDIBLC2   = -2.2630825e-012     WPDIBLC2   = -4.5161068e-011
+PPDIBLC2   = 2.0322481e-018      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097110864        WAIGC      = -9.9755605e-011
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.29196782         LKT1       = 1.3537753e-010
+WKT1       = 1.4126301e-008      PKT1       = -1.2192269e-015     KT1L       = 0
+KT2        = -0.026              UTE        = -0.48880286         LUTE       = -3.1195379e-010
+WUTE       = -4.9680601e-008     PUTE       = 2.8714852e-015      UA1        = 2.869241e-009
+LUA1       = -6.970294e-020      WUA1       = -1.3909609e-018     PUA1       = 6.259324e-026
+UB1        = -2.2820355e-018     LUB1       = 5.8161219e-029      WUB1       = 1.1606394e-027
+PUB1       = -5.2228775e-035     UC1        = -2.0776049e-010     WUC1       = 6.9828923e-017
+PRT        = 0                   AT         = 50000               JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 3.5E-13             JSWD       = 3.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn_hvt'
+CJD        = 'cjn_hvt'           MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'
+CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.6                 PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'
+CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.19E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LAT        = '0+dlatn_hvt'       PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.11 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn_hvt'          TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.145182+dvthn_hvt'
+K1         = 0.158               K2         = 0.050838349         WK2        = -2.755377e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.09842849         WVOFF      = '-5.7950724e-009+dwvoffn_hvt'
+NFACTOR    = 0.56205778          WNFACTOR   = 4.0045612e-007      ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 320.04577           WU0        = -7.7369625e-006
+UA         = -8.7922758e-010     WUA        = 2.6637444e-017      UB         = 2.3367197e-018
+WUB        = -6.8800884e-026     UC         = 2.4280944e-010      WUC        = -3.3952881e-017
+VSAT       = 109346.2            A0         = 4.2844362           WA0        = 1.2963693e-007
+AGS        = 1.0004076           LAGS       = 4.4733147e-007      WAGS       = 3.4681837e-008
+PAGS       = -7.0574531e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.11749778
+WKETA      = 2.4693004e-008      DWG        = 0                   DWB        = 0
+PCLM       = 0.60088889          WPCLM      = 2.1472178e-007      PDIBLC1    = 0.0001
+PDIBLC2    = 0.0025055556        WPDIBLC2   = 1.3420111e-009      PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.25                PDITSD     = 0.3                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.2724
+BETA0      = 10.4                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0099744137
+LAIGC      = -2.2472335e-010     WAIGC      = -1.3420111e-010     PAIGC      = -1.3312286e-029
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2904006          KT1L       = 0
+KT2        = -0.026              UTE        = -2.3349             WUTE       = 5.072802e-007
+UA1        = 8.9472711e-011      WUA1       = 1.5809535e-015      UB1        = -1.8263424e-018
+WUB1       = -1.1086273e-024     UC1        = -2e-010             PRT        = 0
+AT         = 220000              JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 3.5E-13             JSWD       = 3.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.6
+PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.19E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn_hvt'      WVTH0      = '0+dwvthn_hvt'      PVTH0      = '0+dpvthn_hvt'
+LVOFF      = '0+dlvoffn_hvt'     WETA0      = '0+dweta0n_hvt'     LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'     LAT        = '0+dlatn_hvt'       PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.12 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.14529135+dvthn_hvt'
+LVTH0      = '-1.0922832e-010+dlvthn_hvt'
+K1         = 0.158               K2         = 0.052081038         LK2        = -1.2413309e-009
+WK2        = -4.4108414e-009     PK2        = 1.6536549e-015      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.083684316        LVOFF      = '-1.4728058e-008+dlvoffn_hvt'
+WVOFF      = '-1.3792086e-008+dwvoffn_hvt'
+PVOFF      = 7.9882717e-015      NFACTOR    = 0.77259833          LNFACTOR   = -2.1031041e-007
+WNFACTOR   = 2.3202554e-007      PNFACTOR   = 1.6824646e-013      ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 389.06655           LU0        = -6.8945337e-005
+WU0        = -3.657433e-005      PU0        = 2.8805845e-011      UA         = -2.4594121e-010
+LUA        = -6.3259412e-016     WUA        = -2.0731047e-016     PUA        = 2.3369219e-022
+UB         = 2.2192392e-018      LUB        = 1.1735202e-025      WUB        = -2.8598923e-026
+PUB        = -4.0158015e-032     UC         = 2.9342688e-010      LUC        = -5.0562108e-017
+WUC        = -6.3221456e-017     PUC        = 2.9236582e-023      VSAT       = 109346.2
+A0         = 4.2575962           LA0        = 2.6810634e-008      WA0        = 2.6180914e-007
+PA0        = -1.3202773e-013     AGS        = 1.2183201           LAGS       = 2.2965716e-007
+WAGS       = -6.6042377e-008     PAGS       = 3.0039581e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.10713109         LKETA      = -1.0355351e-008     WKETA      = 1.808137e-008
+PKETA      = 6.6044069e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.62932333          LPCLM      = -2.8403364e-008     WPCLM      = 2.3310535e-007
+PPCLM      = -1.8363473e-014     PDIBLC1    = 0.0001              PDIBLC2    = 0.0031063679
+LPDIBLC2   = -6.0015559e-010     WPDIBLC2   = 1.3420111e-009      PPDIBLC2   = -4.5012194e-030
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097494444        WAIGC      = -1.3420111e-010     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.2904006          KT1L       = 0                   KT2        = -0.026
+UTE        = -2.9149629          LUTE       = 5.7942884e-007      WUTE       = 7.2064489e-007
+PUTE       = -2.1313146e-013     UA1        = -9.283565e-010      LUA1       = 1.0167166e-015
+WUA1       = 2.3061288e-015      PUA1       = -7.2438262e-022     UB1        = -1.6993137e-018
+LUB1       = -1.2688989e-025     WUB1       = -1.6360688e-024     PUB1       = 5.2686495e-031
+UC1        = -2.3604874e-010     LUC1       = 3.6009336e-017      PRT        = 0
+AT         = 274073.11           LAT        = '-0.054014003+dlatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthn_hvt'
+PVTH0      = '0+dpvthn_hvt'      WETA0      = '0+dweta0n_hvt'     LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'     PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.13 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.15176207+dvthn_hvt'
+LVTH0      = '-2.5351466e-009+dlvthn_hvt'
+WVTH0      = '-3.3065974e-009+dwvthn_hvt'
+PVTH0      = '1.2396662e-015+dpvthn_hvt'
+K1         = 0.158               K2         = 0.050484157         LK2        = -6.426494e-010
+WK2        = 2.2055004e-009      PK2        = -8.2685734e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.11245757         LVOFF      = '-3.9407674e-009+dlvoffn_hvt'
+WVOFF      = '1.7104395e-008+dwvoffn_hvt'
+PVOFF      = -3.5950319e-015     NFACTOR    = 0.008820312         LNFACTOR   = 7.6035239e-008
+WNFACTOR   = 1.0805568e-006      PNFACTOR   = -1.4987378e-013     ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 175.02137           LU0        = 1.1301679e-005
+WU0        = 6.7607382e-005      PU0        = -1.0252597e-011     UA         = -2.2075542e-009
+LUA        = 1.0282814e-016      WUA        = 5.8760444e-016      PUA        = -6.4326897e-023
+UB         = 2.7637301e-018      LUB        = -8.6781353e-026     WUB        = -1.7000297e-025
+PUB        = 1.2855338e-032      UC         = 1.6014349e-010      LUC        = -5.9324484e-019
+WUC        = 3.9892262e-017      PUC        = -9.4214629e-024     VSAT       = 109346.2
+A0         = 4.2498864           LA0        = 2.9701098e-008      WA0        = 2.8971964e-007
+PA0        = -1.4249157e-013     AGS        = 2.3132036           LAGS       = -1.808222e-007
+WAGS       = 3.3688467e-007      PAGS       = -1.2102055e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.1961974          LKETA      = 2.303622e-008       WKETA      = 5.7686368e-008
+PKETA      = -8.24378e-015       DWG        = 0                   DWB        = 0
+PCLM       = 0.77066436          LPCLM      = -8.1393089e-008     WPCLM      = 1.3221035e-007
+PPCLM      = 1.9462759e-014      PDIBLC1    = 0.0001              PDIBLC2    = 0.0012009886
+LPDIBLC2   = 1.1418424e-010      WPDIBLC2   = 2.1686605e-009      PPDIBLC2   = -3.0991654e-016
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097494444        WAIGC      = -1.3420111e-010     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.29656075         LKT1       = 2.3094826e-009      KT1L       = 0
+KT2        = -0.026              UTE        = -1.4598379          LUTE       = 3.389245e-008
+WUTE       = 1.9303762e-007      PUTE       = -1.5327852e-014     UA1        = 2.0284409e-009
+LUA1       = -9.1807112e-017     WUA1       = 4.748861e-016       PUA1       = -3.7837091e-023
+UB1        = -2.3857868e-018     LUB1       = 1.3047364e-025      WUB1       = -2.9865432e-025
+PUB1       = 2.5459024e-032      UC1        = -1.5231956e-010     LUC1       = 4.6186882e-018
+PRT        = 0                   AT         = 170072.79           LAT        = '-0.015023566+dlatn_hvt'
+WAT        = 0.0082664934        PAT        = '-3.0991654e-009+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.14 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.2070400E-09      LL         = 4.3827800E-03
+WL         = 0                   LLN        = -0.84142000         WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.3827800E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.2070400E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.13671289+dvthn_hvt'
+LVTH0      = '-3.8451499e-010+dlvthn_hvt'
+WVTH0      = '-9.38302e-011+dwvthn_hvt'
+PVTH0      = '7.8053957e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.033090408         LK2        = 1.8430374e-009
+WK2        = -6.0091992e-009     PK2        = 3.4707993e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.13123025         LVOFF      = '-1.258021e-009+dlvoffn_hvt'
+WVOFF      = '-1.1693316e-008+dwvoffn_hvt'
+PVOFF      = 5.2035972e-016      NFACTOR    = -0.044037481        LNFACTOR   = 8.3588982e-008
+WNFACTOR   = -5.4321728e-008     PNFACTOR   = 1.2308198e-014      ETA0       = '0.25034277+deta0n_hvt'
+LETA0      = -3.6216573e-009     WETA0      = '-2.2757811e-008+dweta0n_hvt'
+PETA0      = 3.2522482e-015      ETAB       = -0.11               U0         = 243.36177
+LU0        = 1.535365e-006       WU0        = 2.1619137e-006      PU0        = -8.9998815e-013
+UA         = -2.1093653e-009     LUA        = 8.8796262e-017      WUA        = 1.4606446e-016
+PUA        = -1.2277887e-024     UB         = 2.6075245e-018      LUB        = -6.4458489e-026
+WUB        = 2.6780959e-026      PUB        = -1.5266443e-032     UC         = 1.4512931e-010
+LUC        = 1.552385e-018       WUC        = -1.2016204e-017     PUC        = -2.0033849e-024
+VSAT       = 109346.2            A0         = 2.1355688           LA0        = 3.3185167e-007
+WA0        = -1.089947e-008      PA0        = -9.9531024e-014     AGS        = 1.5385778
+LAGS       = -7.0122824e-008     WAGS       = -7.7395483e-007     PAGS       = 3.7726079e-014
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.0028190108       LKETA      = -4.5988854e-009
+WKETA      = -2.5852873e-008     PKETA      = 3.694554e-015       DWG        = 0
+DWB        = 0                   PCLM       = 0.13403284          LPCLM      = 9.5859479e-009
+WPCLM      = 4.5046471e-007      PPCLM      = -2.6017986e-014     PDIBLC1    = 0.0001
+PDIBLC2    = 0.002               PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097494444        WAIGC      = -1.3420111e-010
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.26136711         LKT1       = -2.7199319e-009
+WKT1       = -6.7363121e-009     PKT1       = 9.6266547e-016      KT1L       = 0
+KT2        = -0.026              UTE        = -2.0650357          LUTE       = 1.2037939e-007
+WUTE       = 4.5665049e-007      PUTE       = -5.2999951e-014     UA1        = -3.6966447e-010
+LUA1       = 2.5089869e-016      WUA1       = 1.0267108e-015      PUA1       = -1.1669665e-022
+UB1        = -7.3643465e-019     LUB1       = -1.0523017e-025     WUB1       = -3.713398e-025
+PUB1       = 3.584628e-032       UC1        = -1.6390235e-010     LUC1       = 6.273949e-018
+WUC1       = 4.5515622e-017      PUC1       = -6.5044964e-024     PRT        = 0
+AT         = 75081.554           LAT        = '-0.0014486629+dlatn_hvt'
+WAT        = -0.022523236        PAT        = '1.3008993e-009+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.15 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.6064050E-09      LL         = 5.4893200E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.4893200E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.6064050E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.075325619+dvthn_hvt'
+LVTH0      = '3.1610971e-009+dlvthn_hvt'
+WVTH0      = '-7.803968e-010+dwvthn_hvt'
+PVTH0      = '8.2019436e-016+dpvthn_hvt'
+K1         = 0.158               K2         = -0.066974981        LK2        = 7.6226241e-009
+WK2        = 7.100254e-008       PK2        = -4.1009718e-015     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.20394738         LVOFF      = '2.9419821e-009+dlvoffn_hvt'
+WVOFF      = '4.7491106e-008+dwvoffn_hvt'
+PVOFF      = -2.8980201e-015     NFACTOR    = -7.6069131          LNFACTOR   = 5.2040631e-007
+WNFACTOR   = 4.4489685e-006      PNFACTOR   = -2.4779329e-013     ETA0       = '0.0025603897+deta0n_hvt'
+LETA0      = 1.0689782e-008      WETA0      = '5.7217791e-008+dweta0n_hvt'
+PETA0      = -1.3669906e-015     ETAB       = -0.11               U0         = 179.32162
+LU0        = 5.2342019e-006      WU0        = 3.5334966e-005      PU0        = -2.8160006e-012
+UA         = -6.6172996e-009     LUA        = 3.4916598e-016      WUA        = 3.1684492e-015
+PUA        = -1.7579499e-022     UB         = 6.8848536e-018      LUB        = -3.115089e-025
+WUB        = -3.2909607e-024     PUB        = 1.7636001e-031      UC         = 2.256373e-010
+LUC        = -3.0976036e-018     WUC        = 1.5968944e-019      PUC        = -2.7066414e-024
+VSAT       = 109346.2            A0         = 29.707642           LA0        = -1.2606589e-006
+WA0        = -1.0406834e-005     PA0        = 5.0091839e-013      AGS        = 0.23651668
+LAGS       = 5.0817494e-009      WAGS       = -7.3445974e-008     PAGS       = -2.7339812e-015
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = 0.031610811         LKETA      = -6.5874865e-009
+WKETA      = -1.6795515e-008     PKETA      = 3.1714182e-015      DWG        = 0
+DWB        = 0                   PCLM       = 0.3                 PDIBLC1    = 0.0001
+PDIBLC2    = 0.002               PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097494444        WAIGC      = -1.3420111e-010
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2820247          LKT1       = -1.5267884e-009
+WKT1       = 5.1973796e-009      PKT1       = 2.7339812e-016      KT1L       = 0
+KT2        = -0.026              UTE        = -0.10546305         LUTE       = 7.1981964e-009
+WUTE       = -3.9391975e-007     PUTE       = -3.8726297e-015     UA1        = 3.9742922e-009
+WUA1       = -9.9372702e-016     UB1        = -2.5583465e-018     WUB1       = 2.4928796e-025
+UC1        = 3.6035327e-010      LUC1       = -2.400606e-017      WUC1       = -4.4033724e-016
+PUC1       = 2.1557442e-023      PRT        = 0                   AT         = 23644.195
+LAT        = '0.0015222612+dlatn_hvt'
+WAT        = 0.023667513         PAT        = '-1.3669906e-009+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.16 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn_hvt'          TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.145182+dvthn_hvt'
+K1         = 0.158               K2         = 0.049492761         WK2        = -2.0314508e-009
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11012509         WVOFF      = '4.9769716e-010+dwvoffn_hvt'
+NFACTOR    = 1.3510012           WNFACTOR   = -2.3995428e-008     ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 282.98661           WU0        = 1.2200865e-005
+UA         = -9.5530771e-010     WUA        = 6.7568554e-017      UB         = 2.1325057e-018
+WUB        = 4.1066234e-026      UC         = 1.8432346e-010      WUC        = -2.4874198e-018
+VSAT       = 109346.2            A0         = 4.4430975           WA0        = 4.4277138e-008
+AGS        = 1.0004413           LAGS       = 3.0158379e-007      WAGS       = 3.4663711e-008
+PAGS       = 7.8377163e-015      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.077412346
+WKETA      = 3.127042e-009       DWG        = 0                   DWB        = 0
+PCLM       = 0.78203704          WPCLM      = 1.1726407e-007      PDIBLC1    = 0.0001
+PDIBLC2    = 0.0050660494        WPDIBLC2   = -3.5534568e-011     PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.25                PDITSD     = 0.3                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.2724
+BETA0      = 10.4                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.009865314
+LAIGC      = -2.9893754e-010     WAIGC      = -7.5505495e-011     PAIGC      = 3.9927235e-017
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.2904006          KT1L       = 0
+KT2        = -0.026              UTE        = -1.392              UA1        = 3.028048e-009
+UB1        = -3.886988e-018      UC1        = -2e-010             PRT        = 0
+AT         = 226604.94           WAT        = -0.0035534568       JSS        = 1.9E-07
+JSD        = 1.9E-07             JSWS       = 3.5E-13             JSWD       = 3.5E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.53                PBD        = 0.53                CJS        = 'cjn_hvt'
+CJD        = 'cjn_hvt'           MJS        = 0.25                MJD        = 0.25
+PBSWS      = 0.7                 PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'
+CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01                MJSWD      = 0.01
+PBSWGS     = 0.6                 PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'
+CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7                 MJSWGD     = 0.7
+TPB        = 1.50E-03            TCJ        = 1.19E-03            TPBSW      = 1.90E-03
+TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn_hvt'      WVTH0      = '0+dwvthn_hvt'
+PVTH0      = '0+dpvthn_hvt'      LVOFF      = '0+dlvoffn_hvt'     WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'     LAT        = '0+dlatn_hvt'
+PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.17 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.14608501+dvthn_hvt'
+LVTH0      = '-9.0202645e-010+dlvthn_hvt'
+WVTH0      = '-4.2699214e-010+dwvthn_hvt'
+PVTH0      = '4.2652539e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.046446781         LK2        = 3.0426508e-009
+WK2        = -1.379611e-009      PK2        = -6.5112727e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10722956         LVOFF      = '-2.8923639e-009+dlvoffn_hvt'
+WVOFF      = '-1.1247449e-009+dwvoffn_hvt'
+PVOFF      = 1.6206685e-015      NFACTOR    = 1.1309767           LNFACTOR   = 2.1978396e-007
+WNFACTOR   = 3.9217983e-008      PNFACTOR   = -6.3144312e-014     ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 290.93572           LU0        = -7.940423e-006
+WU0        = 1.6220057e-005      PU0        = -4.0147982e-012     UA         = -8.3040221e-010
+LUA        = -1.2476897e-016     WUA        = 1.0712955e-016      PUA        = -3.9517748e-023
+UB         = 2.1352994e-018      LUB        = -2.790605e-027      WUB        = 1.6560728e-026
+PUB        = 2.4478719e-032      UC         = 1.6692697e-010      LUC        = 1.7377468e-017
+WUC        = 4.8354954e-018      PUC        = -7.3149105e-024     VSAT       = 109346.2
+A0         = 4.9087382           LA0        = -4.6513169e-007     WA0        = -8.8505248e-008
+PA0        = 1.3263724e-013      AGS        = 1.0507974           LAGS       = 2.5128278e-007
+WAGS       = 2.4084866e-008      PAGS       = 1.8404997e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.071557021        LKETA      = -5.8489238e-009     WKETA      = -1.057481e-009
+PKETA      = 4.1799488e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.81337125          LPCLM      = -3.1299966e-008     WPCLM      = 1.3408756e-007
+PPCLM      = -1.68051e-014       PDIBLC1    = 0.0001              PDIBLC2    = 0.0058255949
+LPDIBLC2   = -7.5871522e-010     WPDIBLC2   = -1.20933e-010       PPDIBLC2   = 8.5305079e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0095660494        WAIGC      = -3.5534568e-011     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.2904006          KT1L       = 0                   KT2        = -0.026
+UTE        = -1.5754743          LUTE       = 1.8327371e-007      UA1        = 3.3581283e-009
+LUA1       = -3.2971948e-016     UB1        = -4.7403338e-018     LUB1       = 8.5241299e-025
+UC1        = -2.3604874e-010     LUC1       = 3.6009336e-017      PRT        = 0
+AT         = 288614.71           LAT        = '-0.061941985+dlatn_hvt'
+WAT        = -0.0078233782       PAT        = '4.2652539e-009+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.18 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.14702088+dvthn_hvt'
+LVTH0      = '-1.2528904e-009+dlvthn_hvt'
+WVTH0      = '-7.5583899e-010+dwvthn_hvt'
+PVTH0      = '5.4981235e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.06218173          LK2        = -2.8564904e-009
+WK2        = -4.0877938e-009     PK2        = 3.6418913e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.08738247         LVOFF      = '-1.0333174e-008+dlvoffn_hvt'
+WVOFF      = '3.6139929e-009+dwvoffn_hvt'
+PVOFF      = -1.5591693e-016     NFACTOR    = 2.3525009           LNFACTOR   = -2.3817388e-007
+WNFACTOR   = -1.8034329e-007     PNFACTOR   = 1.9170726e-014      ETA0       = '0.225+deta0n_hvt'
+ETAB       = -0.11               U0         = 297.79432           LU0        = -1.0511759e-005
+WU0        = 1.5555336e-006      PU0        = 1.4830326e-012      UA         = -1.0178049e-009
+LUA        = -5.4510388e-017     WUA        = -5.2480684e-017     PUA        = 2.0321228e-023
+UB         = 2.3004633e-018      LUB        = -6.4711703e-026     WUB        = 7.9234561e-026
+PUB        = 9.8186638e-034      UC         = 2.7837396e-010      LUC        = -2.4404778e-017
+WUC        = -2.3715732e-017     PUC        = 3.3891418e-024      VSAT       = 109346.2
+A0         = 3.6486441           LA0        = 7.2862743e-009      WA0        = 6.1318798e-007
+PA0        = -1.3043239e-013     AGS        = 3.415296            LAGS       = -6.3518408e-007
+WAGS       = -2.5604107e-007     PAGS       = 1.2342614e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.11928622         LKETA      = 1.2045083e-008      WKETA      = 1.6308155e-008
+PKETA      = -2.3305479e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.72794932          LPCLM      = 7.2530511e-010      WPCLM      = 1.5519103e-007
+PPCLM      = -2.4716937e-014     PDIBLC1    = 0.0001              PDIBLC2    = 0.004952438
+LPDIBLC2   = -4.3136267e-010     WPDIBLC2   = 1.5038073e-010      PPDIBLC2   = -1.6412309e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0095660494        WAIGC      = -3.5534568e-011     BIGC       = 0.0016
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.30062949         LKT1       = 3.8348817e-009      WKT1       = 2.1889826e-009
+PKT1       = -8.2066468e-016     KT1L       = 0                   KT2        = -0.026
+UTE        = -1.1526079          LUTE       = 2.4738189e-008      WUTE       = 2.7747849e-008
+PUTE       = -1.040286e-014      UA1        = 3.1647711e-009      LUA1       = -2.5722852e-016
+WUA1       = -1.3645955e-016     PUA1       = 5.1159629e-023      UB1        = -3.3897539e-018
+LUB1       = 3.4607129e-025      WUB1       = 2.4147998e-025      PUB1       = -9.0532511e-032
+UC1        = -1.5231956e-010     LUC1       = 4.6186882e-018      PRT        = 0
+AT         = 187376.93           LAT        = '-0.023987243+dlatn_hvt'
+WAT        = -0.0010431309       PAT        = '1.7232924e-009+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WETA0      = '0+dweta0n_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.19 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.2070400E-09      LL         = 4.3827800E-03
+WL         = 0                   LLN        = -0.84142000         WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.3827800E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.2070400E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.13003054+dvthn_hvt'
+LVTH0      = '1.1751463e-009+dlvthn_hvt'
+WVTH0      = '3.5012719e-009+dwvthn_hvt'
+PVTH0      = '-5.8558174e-017+dpvthn_hvt'
+K1         = 0.158               K2         = 0.025938955         LK2        = 2.3228523e-009
+WK2        = -2.1617174e-009     PK2        = 8.8939532e-017      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.15971547         LVOFF      = '3.7099174e-012+dlvoffn_hvt'
+WVOFF      = '3.6317288e-009+dwvoffn_hvt'
+PVOFF      = -1.5845153e-016     NFACTOR    = 0.09842185          LNFACTOR   = 8.3949565e-008
+WNFACTOR   = -1.3096485e-007     PNFACTOR   = 1.2114205e-014      ETA0       = '0.19684136+deta0n_hvt'
+LETA0      = 4.0240636e-009      WETA0      = '6.0259485e-009+dweta0n_hvt'
+PETA0      = -8.6114962e-016     ETAB       = -0.11               U0         = 203.25451
+LU0        = 2.998633e-006       WU0        = 2.373962e-005       PU0        = -1.6872263e-012
+UA         = -2.3323557e-009     LUA        = 1.3334799e-016      WUA        = 2.660333e-016
+PUA        = -2.5196618e-023     UB         = 2.7439779e-018      LUB        = -1.28093e-025
+WUB        = -4.6630986e-026     PUB        = 1.8968922e-032      UC         = 1.5415617e-010
+LUC        = -6.6531983e-018     WUC        = -1.6872656e-017     PUC        = 2.4112189e-024
+VSAT       = 109325.5            LVSAT      = '2.9580009e-006+dlvsatn_hvt'
+WVSAT      = 1.1135953e-005      PVSAT      = '-1.5914045e-012+dpvsatn_hvt'
+A0         = 1.6349019           LA0        = 2.9506392e-007      WA0        = 2.584593e-007
+PA0        = -7.9739217e-014     AGS        = 0.39975821          LAGS       = -2.0424292e-007
+WAGS       = -1.6126991e-007     PAGS       = 1.0988269e-013      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.050872679        LKETA      = 2.2683153e-009      DWG        = 0
+DWB        = 0                   PCLM       = 0.98195124          LPCLM      = -3.5573321e-008
+WPCLM      = -5.715387e-009      PPCLM      = -1.7222992e-015     PDIBLC1    = 0.0001
+PDIBLC2    = 0.001889148         LPDIBLC2   = 6.4025994e-012      WPDIBLC2   = 5.9638362e-011
+PPDIBLC2   = -3.4445985e-018     PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0095660494        WAIGC      = -3.5534568e-011
+BIGC       = 0.0016              CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.26280227         LKT1       = -1.5708892e-009
+WKT1       = -5.964194e-009      PKT1       = 3.4448051e-016      KT1L       = 0
+KT2        = -0.026              UTE        = -1.0757368          LUTE       = 1.3752785e-008
+WUTE       = -7.5592325e-008     PUTE       = 4.365164e-015       UA1        = 6.571277e-010
+LUA1       = 1.0113102e-016      WUA1       = 4.7429663e-016      PUA1       = -3.6121644e-023
+UB1        = 5.5692315e-020      LUB1       = -1.4630675e-025     WUB1       = -7.975041e-025
+PUB1       = 5.7945483e-032      UC1        = -7.9300824e-011     LUC1       = -5.8161931e-018
+PRT        = 0                   AT         = -170.61134          LAT        = '0.0028145947+dlatn_hvt'
+WAT        = 0.017962429         PAT        = '-9.9273328e-010+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.20 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.6064050E-09      LL         = 5.4893200E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.4893200E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.6064050E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.029647142+dvthn_hvt'
+LVTH0      = '6.9731008e-009+dlvthn_hvt'
+WVTH0      = '2.3794624e-008+dwvthn_hvt'
+PVTH0      = '-1.2306636e-015+dpvthn_hvt'
+K1         = 0.158               K2         = 0.070232795         LK2        = -2.3547577e-010
+WK2        = -2.8152436e-009     PK2        = 1.2668596e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.081681161        LVOFF      = '-4.5034033e-009+dlvoffn_hvt'
+WVOFF      = '-1.828812e-008+dwvoffn_hvt'
+PVOFF      = 1.1075973e-015      NFACTOR    = 0.72193968          LNFACTOR   = 4.793636e-008
+WNFACTOR   = -3.1954264e-008     PNFACTOR   = 6.3955418e-015      ETA0       = '0.16037063+deta0n_hvt'
+LETA0      = 6.130544e-009       WETA0      = '-2.7684116e-008+dweta0n_hvt'
+PETA0      = 1.0858797e-015      ETAB       = -0.11               U0         = 257.03534
+LU0        = -1.0764607e-007     WU0        = -6.4750154e-006     PU0        = 5.7913583e-014
+UA         = 1.2980413e-010      LUA        = -8.8616857e-018     WUA        = -4.614926e-016
+PUA        = 1.6823896e-023      UB         = -7.2781036e-020     LUB        = 3.4597647e-026
+WUB        = 4.5224676e-025      PUB        = -9.8453091e-033     UC         = 1.9111496e-010
+LUC        = -8.7878676e-018     WUC        = 1.8732709e-017      PUC        = 3.547207e-025
+VSAT       = 120559.15           LVSAT      = '-0.00064587639+dlvsatn_hvt'
+WVSAT      = -0.0060325688       PVSAT      = '3.474815e-010+dpvsatn_hvt'
+A0         = 13.423148           LA0        = -3.8580276e-007     WA0        = -1.6457761e-006
+PA0        = 3.0245803e-014      AGS        = -3.1364198          WAGS       = 1.7411938e-006
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = 0.21518838          LKETA      = -1.3098866e-008
+WKETA      = -1.1556025e-007     PKETA      = 6.6745405e-015      DWG        = 0
+DWB        = 0                   PCLM       = 0.36604938          WPCLM      = -3.5534568e-008
+PDIBLC1    = 0.0001              PDIBLC2    = 0.002               PDIBLCB    = -0.1
+DROUT      = 0.5                 PVAG       = 1.252               DELTA      = 0.01
+PSCBE1     = 1e+009              PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.25                PDITSD     = 0.3                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 75
+RDW        = 75                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.2724
+BETA0      = 10.4                AGIDL      = 2.593e-009          BGIDL      = 1.698e+009
+CGIDL      = 0.25                EGIDL      = 0.2624              AIGBACC    = 0.01152
+BIGBACC    = 0.006537            CIGBACC    = 0.2809              NIGBACC    = 4.05
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0095660494
+WAIGC      = -3.5534568e-011     BIGC       = 0.0016              CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'          CGBO       = 0
+CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.06307            KT1        = -0.30125211
+LKT1       = 6.4990054e-010      WKT1       = 1.5541726e-008      PKT1       = -8.9766054e-016
+KT1L       = 0                   KT2        = -0.026              UTE        = -0.83762677
+WUTE       = -1.5670744e-011     UA1        = 3.2001579e-009      LUA1       = -4.5749578e-017
+WUA1       = -5.7724276e-016     PUA1       = 2.4613273e-023      UB1        = -4.3341534e-018
+LUB1       = 1.0724239e-025      WUB1       = 1.2046721e-024      PUB1       = -5.7696407e-032
+UC1        = -4.5811743e-010     LUC1       = 1.6063534e-017      PRT        = 0
+AT         = 87396.018           LAT        = '-0.0022430875+dlatn_hvt'
+WAT        = -0.010630968        PAT        = '6.5876701e-010+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.21 NMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGEOMOD    = 1                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxn_hvt'          TOXM       = 1.93e-009           DTOX       = 3.7e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.16476295+dvthn_hvt'
+WVTH0      = '-4.1903229e-009+dwvthn_hvt'
+K1         = 0.158               K2         = 0.041962963         WK2        = -4.2007407e-010
+K3         = -4                  K3B        = 1.8                 W0         = 0
+DVT0       = 17                  DVT1       = 1.45                DVT2       = 0.125
+DVT0W      = -2e-006             DVT1W      = 11500               DVT2W      = 0
+DSUB       = 0.65                MINV       = 0                   VOFFL      = 0
+DVTP0      = 8.5e-007            DVTP1      = 2.5                 LPE0       = 1.45e-007
+LPEB       = 3e-008              XJ         = 1.4e-007            NGATE      = 4e+020
+NDEP       = 8.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.1399914          WVOFF      = '6.8890888e-009+dwvoffn_hvt'
+NFACTOR    = 1.1999582           WNFACTOR   = 8.3277585e-009      ETA0       = '0.25935185+deta0n_hvt'
+WETA0      = '-7.3512963e-009+dweta0n_hvt'
+ETAB       = -0.11981481         WETAB      = 2.1003704e-009      U0         = 314.03805
+WU0        = 5.5558577e-006      UA         = -9.7543114e-010     WUA        = 7.1874968e-017
+UB         = 2.3828699e-018      WUB        = -1.2511696e-026     UC         = 1.7044259e-010
+WUC        = 4.8308519e-019      VSAT       = 109346.2            A0         = 4.3606318
+WA0        = 6.19248e-008        AGS        = 1.3074311           LAGS       = 9.3120361e-008
+WAGS       = -3.1032099e-008     PAGS       = 5.2448891e-014      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.050825926        WKETA      = -2.5624519e-009     DWG        = 0
+DWB        = 0                   PCLM       = 0.67240741          WPCLM      = 1.4072481e-007
+PDIBLC1    = 0.0001              PDIBLC2    = 0.0057833333        WPDIBLC2   = -1.8903333e-010
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.010015479         LAIGC      = -2.2264258e-010     WAIGC      = -1.0764075e-010
+PAIGC      = 2.3600113e-017      BIGC       = 0.0018609435        WBIGC      = -5.5841917e-011
+CIGC       = 1.515e-005          AIGSD      = 0.0084              BIGSD      = 0.0004353
+CIGSD      = 3.925e-020          NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'
+CGBO       = 0                   CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 12.6                NOFF       = 2.0                 VOFFCV     = -0.06307
+KT1        = -0.33005304         WKT1       = 8.4856223e-009      KT1L       = 0
+KT2        = -0.026              UTE        = -1.8012778          WUTE       = 8.7585444e-008
+UA1        = 2.7807618e-009      WUA1       = 5.2919252e-017      UB1        = -4.6007302e-018
+WUB1       = 1.5274082e-025      UC1        = -2e-010             PRT        = 0
+AT         = 210000              JSS        = 1.9E-07             JSD        = 1.9E-07
+JSWS       = 3.5E-13             JSWD       = 3.5E-13             JSWGS      = 1.12E-12
+JSWGD      = 1.12E-12            NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.53
+PBD        = 0.53                CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'
+MJS        = 0.25                MJD        = 0.25                PBSWS      = 0.7
+PBSWD      = 0.7                 CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'
+MJSWS      = 0.01                MJSWD      = 0.01                PBSWGS     = 0.6
+PBSWGD     = 0.6                 CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'
+MJSWGS     = 0.7                 MJSWGD     = 0.7                 TPB        = 1.50E-03
+TCJ        = 1.19E-03            TPBSW      = 1.90E-03            TCJSW      = 3.57E-04
+TPBSWG     = 3.00E-03            TCJSWG     = 7.00E-03            XTIS       = 3
+XTID       = 3                   DMCG       = 9.65e-8             DMCI       = 9.65e-8
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn_hvt'      PVTH0      = '0+dpvthn_hvt'      LVOFF      = '0+dlvoffn_hvt'
+LVSAT      = '0+dlvsatn_hvt'     PVSAT      = '0+dpvsatn_hvt'     LAT        = '0+dlatn_hvt'
+PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.22 NMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.16246205+dvthn_hvt'
+LVTH0      = '2.2983825e-009+dlvthn_hvt'
+WVTH0      = '-3.9316781e-009+dwvthn_hvt'
+PVTH0      = '-2.5836213e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.041373277         LK2        = 5.890416e-010
+WK2        = -2.9388123e-010     PK2        = -1.260549e-016      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.14750752         LVOFF      = '7.5078998e-009+dlvoffn_hvt'
+WVOFF      = '7.4947387e-009+dwvoffn_hvt'
+PVOFF      = -6.049879e-016      NFACTOR    = 1.3981841           LNFACTOR   = -1.9800915e-007
+WNFACTOR   = -1.7964394e-008     PNFACTOR   = 2.6263413e-014      ETA0       = '0.25935185+deta0n_hvt'
+WETA0      = '-7.3512963e-009+dweta0n_hvt'
+ETAB       = -0.11981481         WETAB      = 2.1003704e-009      U0         = 352.08516
+LU0        = -3.8005519e-005     WU0        = 3.1340782e-006      PU0        = 2.4191322e-012
+UA         = -6.0604309e-010     LUA        = -3.6898427e-016     WUA        = 5.9116695e-017
+PUA        = 1.2744327e-023      UB         = 2.3502995e-018      LUB        = 3.2534768e-026
+WUB        = -2.94493e-026       PUB        = 1.6919089e-032      UC         = 1.8590906e-010
+LUC        = -1.5449561e-017     WUC        = 7.7332873e-019      PUC        = -2.8992628e-025
+VSAT       = 109346.2            A0         = 3.9246376           LA0        = 4.3551764e-007
+WA0        = 1.2209229e-007      PA0        = -6.0101717e-014     AGS        = 1.2358727
+LAGS       = 1.6460047e-007      WAGS       = -1.5521265e-008     PAGS       = 3.6955011e-014
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.077969292        LKETA      = 2.7113696e-008
+WKETA      = 3.1474498e-010      PKETA      = -2.8740518e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.24161383          LPCLM      = 4.3032267e-007
+WPCLM      = 2.5644365e-007      PPCLM      = -1.1559235e-013     PDIBLC1    = 0.0001
+PDIBLC2    = 0.0070873186        LPDIBLC2   = -1.3025599e-009     WPDIBLC2   = -3.9094188e-010
+PPDIBLC2   = 2.0168784e-016      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097925926        WAIGC      = -8.4014815e-011
+BIGC       = 0.0018609435        WBIGC      = -5.5841917e-011     CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'          CGBO       = 0
+CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.06307            KT1        = -0.35387672
+LKT1       = 2.3797634e-008      WKT1       = 1.3583889e-008      PKT1       = -5.0926937e-015
+KT1L       = 0                   KT2        = -0.026              UTE        = -2.1206022
+LUTE       = 3.1897535e-007      WUTE       = 1.1665737e-007      PUTE       = -2.904015e-014
+UA1        = 3.3328914e-009      LUA1       = -5.5152604e-016     WUA1       = 5.4007053e-018
+PUA1       = 4.7466604e-023      UB1        = -6.2447602e-018     LUB1       = 1.642233e-024
+WUB1       = 3.2194726e-025      PUB1       = -1.6902147e-031     UC1        = -2.2425502e-010
+LUC1       = 2.4228504e-017      WUC1       = -2.5238569e-018     PUC1       = 2.521098e-024
+PRT        = 0                   AT         = 252056.86           LAT        = '-0.042010891+dlatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'     PAT        = '0+dpatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.23 NMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.17674974+dvthn_hvt'
+LVTH0      = '-3.0581703e-009+dlvthn_hvt'
+WVTH0      = '-7.117814e-009+dwvthn_hvt'
+PVTH0      = '9.3614223e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.041792337         LK2        = 4.3193288e-010
+WK2        = 2.7553627e-010      PK2        = -3.3953345e-016     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.11774561         LVOFF      = '-3.6500466e-009+dlvoffn_hvt'
+WVOFF      = '1.0111704e-008+dwvoffn_hvt'
+PVOFF      = -1.5861063e-015     NFACTOR    = 1.0136603           LNFACTOR   = -5.3848524e-008
+WNFACTOR   = 1.0616859e-007      PNFACTOR   = -2.0274901e-014     ETA0       = '0.25935185+deta0n_hvt'
+WETA0      = '-7.3512963e-009+dweta0n_hvt'
+ETAB       = -0.11981481         WETAB      = 2.1003704e-009      U0         = 241.13513
+LU0        = 3.5904112e-006      WU0        = 1.3680601e-005      PU0        = -1.5348319e-012
+UA         = -1.7991512e-009     LUA        = 7.832018e-017       WUA        = 1.1472741e-016
+PUA        = -8.1045132e-024     UB         = 2.7095063e-018      LUB        = -1.0213435e-025
+WUB        = -8.3006447e-027     PUB        = 8.9903123e-033      UC         = 1.4905291e-010
+LUC        = -1.6319365e-018     WUC        = 3.9589728e-018      PUC        = -1.4842462e-024
+VSAT       = 109346.2            A0         = 7.7565624           LA0        = -1.0010974e-006
+WA0        = -2.6590653e-007     PA0        = 8.5361717e-014      AGS        = 5.2467749
+LAGS       = -1.3391144e-006     WAGS       = -6.4797754e-007     PAGS       = 2.7406723e-013
+A1         = 0                   A2         = 1                   B0         = 0
+B1         = 0                   KETA       = -0.011750893        LKETA      = 2.2879613e-009
+WKETA      = -6.7044053e-009     PKETA      = -2.4252389e-016     DWG        = 0
+DWB        = 0                   PCLM       = 1.9355817           LPCLM      = -2.0475757e-007
+WPCLM      = -1.0324229e-007     PPCLM      = 1.9256397e-014      PDIBLC1    = 0.0001
+PDIBLC2    = 0.0050890288        LPDIBLC2   = -5.5338727e-010     WPDIBLC2   = 1.2115029e-010
+PPDIBLC2   = 9.7009558e-018      PDIBLCB    = -0.1                DROUT      = 0.5
+PVAG       = 1.252               DELTA      = 0.01                PSCBE1     = 1e+009
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.25
+PDITSD     = 0.3                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 75                  RDW        = 75
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.2724              BETA0      = 10.4
+AGIDL      = 2.593e-009          BGIDL      = 1.698e+009          CGIDL      = 0.25
+EGIDL      = 0.2624              AIGBACC    = 0.01152             BIGBACC    = 0.006537
+CIGBACC    = 0.2809              NIGBACC    = 4.05                AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0097925926        WAIGC      = -8.4014815e-011
+BIGC       = 0.0018609435        WBIGC      = -5.5841917e-011     CIGC       = 1.515e-005
+AIGSD      = 0.0084              BIGSD      = 0.0004353           CIGSD      = 3.925e-020
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 3.767
+NTOX       = 'ntoxn_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_hvt'          CGDO       = 'cgon_hvt'          CGBO       = 0
+CGDL       = 'cgln_hvt'          CGSL       = 'cgln_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 12.6
+NOFF       = 2.0                 VOFFCV     = -0.06307            KT1        = -0.2904006
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.2040704
+LUTE       = -2.463873e-008      WUTE       = 3.8760832e-008      PUTE       = 1.6380064e-016
+UA1        = 1.8144129e-009      LUA1       = 1.7762016e-017      WUA1       = 1.525171e-016
+PUA1       = -7.688347e-024      UB1        = -1.3968892e-018     LUB1       = -1.7526732e-025
+WUB1       = -1.8499306e-025     PUB1       = 2.1033952e-032      UC1        = -1.8404061e-010
+LUC1       = 9.1518451e-018      WUC1       = 6.7883047e-018      PUC1       = -9.7009558e-025
+PRT        = 0                   AT         = 175852.2            LAT        = '-0.013441238+dlatn_hvt'
+WAT        = 0.0014231602        PAT        = '-5.3355257e-010+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatn_hvt'
+PVSAT      = '0+dpvsatn_hvt'
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.24 NMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.2070400E-09      LL         = 4.3827800E-03
+WL         = 0                   LLN        = -0.84142000         WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.3827800E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.2070400E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.14285008+dvthn_hvt'
+LVTH0      = '1.7863252e-009+dlvthn_hvt'
+WVTH0      = '7.5789182e-010+dwvthn_hvt'
+PVTH0      = '-1.8935047e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.026271441         LK2        = 2.649976e-009
+WK2        = -2.2328696e-009     PK2        = 1.8935047e-017      K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.12887777         LVOFF      = '-2.0591837e-009+dlvoffn_hvt'
+WVOFF      = '-2.9675382e-009+dwvoffn_hvt'
+PVOFF      = 2.830077e-016       NFACTOR    = -0.84603016         LNFACTOR   = 2.1191407e-007
+WNFACTOR   = 7.1147883e-008      PNFACTOR   = -1.52702e-014       ETA0       = '0.29929734+deta0n_hvt'
+LETA0      = -5.7084858e-009     WETA0      = '-1.5899631e-008+dweta0n_hvt'
+PETA0      = 1.221616e-015       ETAB       = -0.11981481         WETAB      = 2.1003704e-009
+U0         = 334.00078           LU0        = -9.6807303e-006     WU0        = -4.2400823e-006
+PU0        = 1.0261574e-012      UA         = -8.8630105e-010     LUA        = -5.2132401e-017
+WUA        = -4.34224e-017       PUA        = 1.4496186e-023      UB         = 2.5012432e-018
+LUB        = -7.2372111e-026     WUB        = 5.3142349e-027      PUB        = 7.044652e-033
+UC         = 7.8981299e-011      LUC        = 8.3817805e-018      WUC        = -7.8523267e-019
+PUC        = -8.0626653e-025     VSAT       = 139802.68           LVSAT      = '-0.0043524418+dlvsatn_hvt'
+WVSAT      = -0.0065109813       PVSAT      = '9.3046416e-010+dpvsatn_hvt'
+A0         = 1.2421135           LA0        = -7.0137724e-008     WA0        = 3.4251603e-007
+PA0        = -1.5860647e-015     AGS        = -10.312589          LAGS       = 8.8442604e-007
+WAGS       = 2.1311724e-006      PAGS       = -1.2309247e-013     A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = 0.015016906         LKETA      = -1.5373419e-009     WKETA      = -1.4100371e-008
+PKETA      = 8.1441064e-016      DWG        = 0                   DWB        = 0
+PCLM       = 0.70815788          LPCLM      = -2.9350234e-008     WPCLM      = 5.2876391e-008
+PPCLM      = -3.0540399e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.00068531631
+LPDIBLC2   = 7.5933632e-011      WPDIBLC2   = 3.1725835e-010      PPDIBLC2   = -1.8324239e-017
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097925926        WAIGC      = -8.4014815e-011     BIGC       = 0.0018609435
+WBIGC      = -5.5841917e-011     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.29067233         LKT1       = 3.8832782e-011
+KT1L       = 0                   KT2        = -0.026              UTE        = -1.8500001
+LUTE       = 6.7669073e-008      WUTE       = 9.0100007e-008      PUTE       = -7.1729217e-015
+UA1        = 2.7816665e-009      LUA1       = -1.2046521e-016     WUA1       = 1.9645315e-017
+PUA1       = 1.1299948e-023      UB1        = -4.3291564e-018     LUB1       = 2.4377389e-025
+WUB1       = 1.4085352e-025      PUB1       = -2.5531774e-032     UC1        = -7.9300824e-011
+LUC1       = -5.8161931e-018     PRT        = 0                   AT         = 100434.26
+LAT        = '-0.0026634933+dlatn_hvt'
+WAT        = -0.0035670126       PAT        = '1.7957755e-010+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

.MODEL nch_hvt.25 NMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   BINUNIT    = 2                   PARAMCHK   = 1
+MOBMOD     = 0                   CAPMOD     = 2                   IGCMOD     = 1
+IGBMOD     = 1                   GEOMOD     = 0                   DIOMOD     = 1
+RDSMOD     = 1                   RBODYMOD   = 0                   RGEOMOD    = 1
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxn_hvt'
+TOXM       = 1.93e-009           DTOX       = 3.7e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.6064050E-09      LL         = 5.4893200E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.4893200E-03       WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.6064050E-09+ddlcn_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '0.18377143+dvthn_hvt'
+LVTH0      = '-5.772143e-010+dlvthn_hvt'
+WVTH0      = '-9.1879733e-009+dwvthn_hvt'
+PVTH0      = '3.851038e-016+dpvthn_hvt'
+K1         = 0.158               K2         = 0.062759965         LK2        = 5.4246826e-010
+WK2        = -1.2160579e-009     PK2        = -3.9794059e-017     K3         = -4
+K3B        = 1.8                 W0         = 0                   DVT0       = 17
+DVT1       = 1.45                DVT2       = 0.125               DVT0W      = -2e-006
+DVT1W      = 11500               DVT2W      = 0                   DSUB       = 0.65
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8.5e-007
+DVTP1      = 2.5                 LPE0       = 1.45e-007           LPEB       = 3e-008
+XJ         = 1.4e-007            NGATE      = 4e+020              NDEP       = 8.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.23190513         LVOFF      = '3.8914807e-009+dlvoffn_hvt'
+WVOFF      = '1.3859809e-008+dwvoffn_hvt'
+PVOFF      = -6.8890791e-016     NFACTOR    = 0.15315581          LNFACTOR   = 1.5420299e-007
+WNFACTOR   = 8.9765484e-008      PNFACTOR   = -1.6345517e-014     ETA0       = '-0.18393336+deta0n_hvt'
+LETA0      = 2.2202001e-008      WETA0      = '4.5996936e-008+dweta0n_hvt'
+PETA0      = -2.3534121e-015     ETAB       = -0.11981481         WETAB      = 2.1003704e-009
+U0         = -134.49469          LU0        = 1.7378678e-005      WU0        = 7.7312411e-005
+PU0        = -3.6841597e-012     UA         = -6.6322414e-009     LUA        = 2.7974219e-016
+WUA        = 9.8558513e-016      PUA        = -4.4937334e-023     UB         = 1.9338651e-018
+LUB        = -3.9601428e-026     WUB        = 2.2824492e-026      PUB        = 6.0332928e-033
+UC         = 1.0053031e-009      LUC        = -4.5120804e-017     WUC        = -1.5550354e-016
+PUC        = 8.1299691e-024      VSAT       = 30898.981           LVSAT      = '0.0019376292+dlvsatn_hvt'
+WVSAT      = 0.013154708         PVSAT      = '-2.0538869e-010+dpvsatn_hvt'
+A0         = 4.9527535           LA0        = -2.8445724e-007     WA0        = 1.6688825e-007
+PA0        = 8.5578622e-015      AGS        = 5                   A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.45359371         LKETA      = 2.5528717e-008      WKETA      = 2.7559119e-008
+PKETA      = -1.5917624e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.02690735          LPCLM      = 9.9975026e-009      WPCLM      = 3.7041827e-008
+PPCLM      = -2.1394655e-015     PDIBLC1    = 0.0001              PDIBLC2    = 0.002
+PDIBLCB    = -0.1                DROUT      = 0.5                 PVAG       = 1.252
+DELTA      = 0.01                PSCBE1     = 1e+009              PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.25                PDITSD     = 0.3
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 75                  RDW        = 75                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.2724              BETA0      = 10.4                AGIDL      = 2.593e-009
+BGIDL      = 1.698e+009          CGIDL      = 0.25                EGIDL      = 0.2624
+AIGBACC    = 0.01152             BIGBACC    = 0.006537            CIGBACC    = 0.2809
+NIGBACC    = 4.05                AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0097925926        WAIGC      = -8.4014815e-011     BIGC       = 0.0018609435
+WBIGC      = -5.5841917e-011     CIGC       = 1.515e-005          AIGSD      = 0.0084
+BIGSD      = 0.0004353           CIGSD      = 3.925e-020          NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 3.767               NTOX       = 'ntoxn_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_hvt'
+CGDO       = 'cgon_hvt'          CGBO       = 0                   CGDL       = 'cgln_hvt'
+CGSL       = 'cgln_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 12.6                NOFF       = 2.0
+VOFFCV     = -0.06307            KT1        = -0.04930324         LKT1       = -1.3902188e-008
+WKT1       = -3.8375333e-008     PKT1       = 2.2164863e-015      KT1L       = 0
+KT2        = -0.026              UTE        = -0.67840556         WUTE       = -3.4089011e-008
+UA1        = -7.9531643e-009     LUA1       = 4.9955823e-016      WUA1       = 1.8095682e-015
+PUA1       = -9.2082597e-023     UB1        = 1.0554082e-017      LUB1       = -6.158537e-025
+WUB1       = -1.9814104e-024     PUB1       = 9.7046157e-032      UC1        = -3.8559161e-010
+LUC1       = 1.1874581e-017      WUC1       = -1.5520526e-017     PUC1       = 8.9643607e-025
+PRT        = 0                   AT         = 77592.426           LAT        = '-0.0013441925+dlatn_hvt'
+WAT        = -0.008532999        PAT        = '4.6640349e-010+dpatn_hvt'
+JSS        = 1.9E-07             JSD        = 1.9E-07             JSWS       = 3.5E-13
+JSWD       = 3.5E-13             JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.53                PBD        = 0.53
+CJS        = 'cjn_hvt'           CJD        = 'cjn_hvt'           MJS        = 0.25
+MJD        = 0.25                PBSWS      = 0.7                 PBSWD      = 0.7
+CJSWS      = 'cjswn_hvt'         CJSWD      = 'cjswn_hvt'         MJSWS      = 0.01
+MJSWD      = 0.01                PBSWGS     = 0.6                 PBSWGD     = 0.6
+CJSWGS     = 'cjswgn_hvt'        CJSWGD     = 'cjswgn_hvt'        MJSWGS     = 0.7
+MJSWGD     = 0.7                 TPB        = 1.50E-03            TCJ        = 1.19E-03
+TPBSW      = 1.90E-03            TCJSW      = 3.57E-04            TPBSWG     = 3.00E-03
+TCJSWG     = 7.00E-03            XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50
+SAREF      = 0.567E-6            SBREF      = 0.567E-6
+KVSAT      = 0.4                 WLOD       = 2E-7                TKU0       = 0.01
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 7.02E-7             WKU0       = 6.8E-7              PKU0       = 0
+KVTH0      = 4.8E-9              STK2       = 0.88E-9             STETA0     = 0
+LKVTH0     = -2.68E-11           WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1 )

**********************************************************************************************
*                                                                                            *
*                              1.05V HIGH-VT PMOS DEVICE MODELS                              *
*                                                                                            *
**********************************************************************************************

.MODEL pch_hvt.1 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp_hvt'          TOXM       = 2.13e-009           DTOX       = 6.3e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17+dvthp_hvt'   K1         = 0.11                K2         = 0.01699314
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.087+dvoffp_hvt' NFACTOR    = 1.9
+ETA0       = 0.42                ETAB       = -0.02               U0         = '87.967229+du0p_hvt'
+LU0        = 3.1117194e-011      WU0        = 2.8035747e-008      PU0        = '-2.8005101e-014+dpu0p_hvt'
+UA         = 2.5500799e-010      LUA        = -8.9717456e-023     WUA        = -8.0832993e-020
+PUA        = 8.0744634e-026      UB         = 1.7346662e-018      LUB        = 3.7476912e-030
+WUB        = 3.3765681e-027      PUB        = -3.3728771e-033     UC         = -5.1e-012
+VSAT       = 160000              A0         = 8.2                 AGS        = 0.50038949
+LAGS       = 1.2482446e-006      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.11580667
+LKETA      = 4.0622702e-010      WKETA      = 3.6599951e-007      PKETA      = -3.6559944e-013
+DWG        = 0                   DWB        = 0                   PCLM       = 0.4
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055276706
+LAIGC      = -2.4739982e-010     BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014
+CIGC       = 1e-010              AIGSD      = 0.00419             BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9000478           LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.32               KT1L       = 0
+KT2        = -0.03875            UTE        = -1.2                UA1        = 5.13e-009
+UB1        = -9e-018             UC1        = -1.1e-010           PRT        = 0
+AT         = 203649.22           LAT        = '0.1461908+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp_hvt'
+WVTH0      = '0+dwvthp_hvt'      PVTH0      = '0+dpvthp_hvt'      LK2        = '0+dlk2p_hvt'
+LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'
+PNFACTOR   = '0+dpnfactorp_hvt'  LVOFF      = '0+dlvoffp_hvt'     PVOFF      = '0+dpvoffp_hvt'
+LETA0      = '0+dleta0p_hvt'     WETA0      = '0+dweta0p_hvt'     PA0        = '0+dpa0p_hvt'
+LKT1       = '0+dlkt1p_hvt'      PKT1       = '0+dpkt1p_hvt'      PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.2 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16879838+dvthp_hvt'
+LVTH0      = '-1.2003112e-009+dlvthp_hvt'
+K1         = 0.11                K2         = 0.015997678         LK2        = '9.9437379e-010+dlk2p_hvt'
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.079564947+dvoffp_hvt'
+LVOFF      = '-7.4269254e-009+dlvoffp_hvt'
+NFACTOR    = 1.9600812           LNFACTOR   = -6.0015559e-008     ETA0       = 0.42
+ETAB       = -0.02               U0         = '95.714454+du0p_hvt'
+LU0        = -7.7387259e-006     WU0        = 1.4743904e-008      PU0        = '-1.4727787e-014+dpu0p_hvt'
+UA         = 6.9799158e-010      LUA        = -4.4249946e-016     UB         = 1.2099626e-018
+LUB        = 5.2413388e-025      UC         = -3.5200698e-011     LUC        = 3.0067795e-017
+VSAT       = 160000              A0         = 8.6818515           LA0        = -4.8132478e-007
+AGS        = 0.66853779          LAGS       = 1.0802801e-006      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.094611893        LKETA      = -2.0765383e-008     DWG        = 0
+DWB        = 0                   PCLM       = 0.039512596         LPCLM      = 3.6009336e-007
+PDIBLC1    = 0                   PDIBLC2    = 0.00039918766       LPDIBLC2   = 6.0015559e-010
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0053160487        LAIGC      = -3.6009336e-011     BIGC       = 0.00099264429
+LBIGC      = 2.0885415e-014      CIGC       = 1e-010              AIGSD      = 0.00419
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'          CGBO       = 0
+CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 1.827               VOFFCV     = -0.03               KT1        = -0.32600812
+LKT1       = '6.0015559e-009+dlkt1p_hvt'
+KT1L       = 0                   KT2        = -0.06503554         LKT2       = 2.6256807e-008
+UTE        = -1.4549247          LUTE       = 2.5464602e-007      UA1        = 6.1393647e-009
+LUA1       = -1.0082614e-015     UB1        = -1.2031699e-017     LUB1       = 3.0283851e-024
+UC1        = -1.1e-010           PRT        = 0                   AT         = 350000
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'  PVOFF      = '0+dpvoffp_hvt'
+LETA0      = '0+dleta0p_hvt'     WETA0      = '0+dweta0p_hvt'     PA0        = '0+dpa0p_hvt'
+PKT1       = '0+dpkt1p_hvt'      LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.3 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17323196+dvthp_hvt'
+LVTH0      = '4.6186882e-010+dlvthp_hvt'
+K1         = 0.11                K2         = 0.019667867         LK2        = '-3.8160525e-010+dlk2p_hvt'
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.081126651+dvoffp_hvt'
+LVOFF      = '-6.8414319e-009+dlvoffp_hvt'
+NFACTOR    = 1.9231956           LNFACTOR   = -4.6186882e-008     ETA0       = 0.42
+ETAB       = -0.02               U0         = '87.015769+du0p_hvt'
+LU0        = -4.4775289e-006     WU0        = -3.9656017e-008     PU0        = '5.6671184e-015+dpu0p_hvt'
+UA         = -1.8506714e-010     LUA        = -1.1143465e-016     UB         = 2.7090407e-018
+LUB        = -3.7880864e-026     UC         = 3.6992286e-011      LUC        = 3.0021473e-018
+VSAT       = 160000              A0         = 8.0528117           LA0        = -2.4549344e-007
+AGS        = -0.78949737         LAGS       = 1.6269075e-006      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.1192011          LKETA      = -1.154672e-008      DWG        = 0
+DWB        = 0                   PCLM       = 1                   PDIBLC1    = 0
+PDIBLC2    = 0.002               PDIBLCB    = 0                   DROUT      = 0
+PVAG       = 0                   DELTA      = 0.020306            PSCBE1     = 9.264e+008
+PSCBE2     = 1e-020              FPROUT     = 0                   PDITS      = 0.1295569
+PDITSD     = -2.203938           PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 0                   ALPHA1     = 0.7                 BETA0      = 14.31
+AGIDL      = 7.379e-008          BGIDL      = 2.3e+009            CGIDL      = 0.5
+EGIDL      = 0.53                AIGBACC    = 0.01095             BIGBACC    = 0.00456
+CIGBACC    = 0.2247              NIGBACC    = 4.046               AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 1                   AIGC       = 0.0052939174        LAIGC      = -2.7712129e-011
+BIGC       = 0.0009927           CIGC       = 1e-010              AIGSD      = 0.00419
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.31615978         LKT1       = '2.3093441e-009+dlkt1p_hvt'
+KT1L       = 0                   KT2        = 0.031949038         LKT2       = -1.010338e-008
+UTE        = -0.91153098         LUTE       = 5.092397e-008       UA1        = 3.0632286e-009
+LUA1       = 1.4500325e-016      UB1        = -3.2964638e-018     LUB1       = -2.4651486e-025
+UC1        = -1.2847934e-010     LUC1       = 6.9280323e-018      PRT        = 0
+AT         = 430077.14           LAT        = '-0.030021473+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'  PVOFF      = '0+dpvoffp_hvt'
+LETA0      = '0+dleta0p_hvt'     WETA0      = '0+dweta0p_hvt'     PA0        = '0+dpa0p_hvt'
+PKT1       = '0+dpkt1p_hvt'      PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.4 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.20704E-09        LL         = 4.38278E-03
+WL         = 0                   LLN        = -0.84142            WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.38278E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.20704E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16864336+dvthp_hvt'
+LVTH0      = '-1.938731e-010+dlvthp_hvt'
+K1         = 0.11                K2         = -0.0019970439       LK2        = '2.71446e-009+dlk2p_hvt'
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.11272033+dvoffp_hvt'
+LVOFF      = '-2.3264772e-009+dlvoffp_hvt'
+NFACTOR    = 0.51468864          LNFACTOR   = 1.5509848e-007      ETA0       = 0.43356639
+LETA0      = '-1.938731e-009+dleta0p_hvt'
+ETAB       = -0.02               U0         = '62.795469+du0p_hvt'
+LU0        = -1.0162809e-006     UA         = -7.0787035e-010     LUA        = -3.6722464e-017
+UB         = 2.4717103e-018      LUB        = -3.9647049e-027     UC         = 5.8e-011
+VSAT       = 160000              A0         = 7.2404828           LA0        = -1.2940603e-007
+AGS        = 4.2152195           LAGS       = 9.1169893e-007      A1         = 0
+A2         = 1                   B0         = 0                   B1         = 0
+KETA       = -0.21356639         LKETA      = 1.938731e-009       DWG        = 0
+DWB        = 0                   PCLM       = 1.3391598           LPCLM      = -4.8468276e-008
+PDIBLC1    = 0                   PDIBLC2    = 0.0026783196        LPDIBLC2   = -9.6936551e-011
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0051746152        LAIGC      = -1.0663021e-011     BIGC       = 0.0009927
+CIGC       = 1e-010              AIGSD      = 0.00419             BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.25930082         LKT1       = '-5.8161931e-009+dlkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.64397072
+LUTE       = 1.2687763e-008      UA1        = 5.1678884e-009      LUA1       = -1.5576715e-016
+UB1        = -7.1293228e-018     LUB1       = 3.0122713e-025      UC1        = -8e-011
+PRT        = 0                   AT         = 247132.78           LAT        = '-0.0038774621+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      PU0        = '0+dpu0p_hvt'       LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'
+PVOFF      = '0+dpvoffp_hvt'     WETA0      = '0+dweta0p_hvt'     PA0        = '0+dpa0p_hvt'
+PKT1       = '0+dpkt1p_hvt'      PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.5 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '9e-006-dxw_hvt'    WMAX       = 900.01e-06          VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.606405E-09       LL         = 5.48932E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.48932E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.606405E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.18610868+dvthp_hvt'
+LVTH0      = '8.1489078e-010+dlvthp_hvt'
+K1         = 0.11                K2         = -0.025543419        LK2        = '4.0744539e-009+dlk2p_hvt'
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '0.083320455+dvoffp_hvt'
+LVOFF      = '-1.364942e-008+dlvoffp_hvt'
+NFACTOR    = -4.5597761          LNFACTOR   = 4.4818993e-007      ETA0       = 0.18836974
+LETA0      = '1.2223362e-008+dleta0p_hvt'
+ETAB       = -0.02               U0         = '53.383037+du0p_hvt'
+LU0        = -4.7263665e-007     UA         = -4.4659555e-010     LUA        = -5.18132e-017
+UB         = 2.6078792e-018      LUB        = -1.1829566e-026     UC         = 5.8e-011
+VSAT       = 248179.27           LVSAT      = '-0.0050930673+dlvsatp_hvt'
+A0         = -2.0543419          LA0        = 4.0744539e-007      AGS        = 23.527171
+LAGS       = -2.0372269e-007     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.32108684
+LKETA      = 8.1489078e-009      DWG        = 0                   DWB        = 0
+PCLM       = 0.5                 PDIBLC1    = 0                   PDIBLC2    = 0.001
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.00499             BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.00419             BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'          CGBO       = 0
+CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 1.827               VOFFCV     = -0.03               KT1        = -0.27182073
+LKT1       = '-5.0930673e-009+dlkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.2179605
+LUTE       = -1.1917778e-008     UA1        = 6.4002685e-009      LUA1       = -2.2694708e-016
+UB1        = -5.9476727e-018     LUB1       = 2.3297727e-025      UC1        = -2.2108684e-010
+LUC1       = 8.1489078e-018      PRT        = 0                   AT         = 250543.42
+LAT        = '-0.0040744539+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      PU0        = '0+dpu0p_hvt'       PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'  PVOFF      = '0+dpvoffp_hvt'
+WETA0      = '0+dweta0p_hvt'     PA0        = '0+dpa0p_hvt'       PKT1       = '0+dpkt1p_hvt'
+PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.6 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp_hvt'          TOXM       = 2.13e-009           DTOX       = 6.3e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16966741+dvthp_hvt'
+WVTH0      = '-2.9926681e-009+dwvthp_hvt'
+K1         = 0.11                K2         = 0.017258454         WK2        = -2.3872913e-009
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.085780494+dvoffp_hvt'
+WVOFF      = -1.0973117e-008     NFACTOR    = 1.9997778           WNFACTOR   = -8.9780044e-007
+ETA0       = 0.42                ETAB       = -0.02               U0         = '88.85397+du0p_hvt'
+LU0        = -3.4228529e-009     WU0        = -7.9508655e-006     PU0        = '3.0737219e-015+dpu0p_hvt'
+UA         = 3.7861248e-010      LUA        = 9.8688095e-021      WUA        = -1.112274e-015
+PUA        = -8.8621909e-027     UB         = 1.6225189e-018      LUB        = -4.1224141e-028
+WUB        = 1.012478e-024       PUB        = 3.7019278e-034      UC         = -7.8826914e-012
+WUC        = 2.5038657e-017      VSAT       = 160000              A0         = 8.1756135
+LA0        = -3.2414652e-011     WA0        = 2.1942971e-007      PA0        = '2.9166704e-016+dpa0p_hvt'
+AGS        = 0.49096939          LAGS       = 1.2432584e-006      WAGS       = 8.4762084e-008
+PAGS       = 4.4865122e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.078621358
+LKETA      = -3.2906731e-008     WKETA      = 3.1406063e-008      PKETA      = -6.5849444e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.4
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055309965
+LAIGC      = -2.4739982e-010     WAIGC      = -2.9926681e-011     PAIGC      = 9.7212735e-031
+BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014     CIGC       = 1e-010
+AIGSD      = 0.0041863952        LAIGSD     = 2.4934348e-012      WAIGSD     = 3.2436038e-011
+PAIGSD     = -2.2435926e-017     BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.32443457         WKT1       = 3.9902242e-008      KT1L       = 0
+KT2        = -0.03875            UTE        = -1.2610061          LUTE       = -2.4186318e-012
+WUTE       = 5.4893331e-007      PUTE       = 2.1762849e-017      UA1        = 5.2091066e-009
+LUA1       = -6.0341122e-020     WUA1       = -7.1180101e-016     PUA1       = 5.4294942e-025
+UB1        = -9.4061426e-018     LUB1       = 4.7001246e-029      WUB1       = 3.6544712e-024
+PUB1       = -4.2291721e-034     UC1        = -1.1e-010           PRT        = 0
+AT         = 203649.22           LAT        = '0.1461908+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LK2        = '0+dlk2p_hvt'       LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'
+LVOFF      = '0+dlvoffp_hvt'     PVOFF      = '0+dpvoffp_hvt'     LETA0      = '0+dleta0p_hvt'
+WETA0      = '0+dweta0p_hvt'     LKT1       = '0+dlkt1p_hvt'      PKT1       = '0+dpkt1p_hvt'
+PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.7 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16813274+dvthp_hvt'
+LVTH0      = '-1.53299e-009+dlvthp_hvt'
+WVTH0      = '-5.9893881e-009+dwvthp_hvt'
+PVTH0      = '2.9934442e-015+dpvthp_hvt'
+K1         = 0.11                K2         = 0.016422607         LK2        = '8.349328e-010+dlk2p_hvt'
+WK2        = -3.8235113e-009     PK2        = 1.43465e-015        K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.077720986+dvoffp_hvt'
+LVOFF      = '-8.0506983e-009+dlvoffp_hvt'
+WVOFF      = -1.6591966e-008     PVOFF      = '5.6127079e-015+dpvoffp_hvt'
+NFACTOR    = 2.0865024           LNFACTOR   = -8.6629866e-008     WNFACTOR   = -1.137538e-006
+PNFACTOR   = '2.3947554e-013+dpnfactorp_hvt'
+ETA0       = 0.42                ETAB       = -0.02               U0         = '96.052351+du0p_hvt'
+LU0        = -7.1939351e-006     WU0        = -3.025652e-006      PU0        = '-4.9167561e-012+dpu0p_hvt'
+UA         = 8.3608061e-010      LUA        = -4.5695821e-016     WUA        = -1.2425251e-015
+PUA        = 1.3009981e-022      UB         = 1.034898e-018       LUB        = 5.8656639e-025
+WUB        = 1.575231e-024       PUB        = -5.617677e-031      UC         = -3.8656136e-011
+LUC        = 3.0739806e-017      WUC        = 3.1092031e-017      PUC        = -6.0467573e-024
+VSAT       = 160000              A0         = 8.6461374           LA0        = -4.7004198e-007
+WA0        = 3.2135545e-007      PA0        = '-1.0152266e-013+dpa0p_hvt'
+AGS        = 0.62434321          LAGS       = 1.1100304e-006      WAGS       = 3.9766277e-007
+PAGS       = -2.6769354e-013     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.088471335
+LKETA      = -2.3067521e-008     WKETA      = -5.5252741e-008     PKETA      = 2.0714634e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.039512596
+LPCLM      = 3.6009336e-007      PDIBLC1    = 0                   PDIBLC2    = 0.00053240482
+LPDIBLC2   = 4.6708406e-010      WPDIBLC2   = -1.198688e-009      PPDIBLC2   = 1.1973777e-015
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0053200408        LAIGC      = -3.6674693e-011     WAIGC      = -3.5920121e-011
+PAIGC      = 5.9868884e-018      BIGC       = 0.00099264429       LBIGC      = 2.0885415e-014
+CIGC       = 1e-010              AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'          CGBO       = 0
+CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 1.827               VOFFCV     = -0.03               KT1        = -0.33443921
+LKT1       = '9.993702e-009+dlkt1p_hvt'
+WKT1       = 7.5862881e-008      PKT1       = '-3.592133e-014+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.067701215        LKT2       = 2.8919569e-008
+WKT2       = 2.3985746e-008      PKT2       = -2.3959527e-014     UTE        = -1.5787185
+LUTE       = 3.1736263e-007      WUTE       = 1.1138967e-006      PUTE       = -5.643241e-013
+UA1        = 6.1271572e-009      LUA1       = -9.1710739e-016     WUA1       = 1.0984379e-016
+PUA1       = -8.2020371e-022     UB1        = -1.2545967e-017     LUB1       = 3.1364392e-024
+WUB1       = 4.6273824e-024      PUB1       = -9.7227068e-031     UC1        = -1.1e-010
+PRT        = 0                   AT         = 350000              JSS        = 1.4E-07
+JSD        = 1.4E-07             JSWS       = 6.00E-13            JSWD       = 6.00E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_hvt'
+CJD        = 'cjp_hvt'           MJS        = 0.35                MJD        = 0.35
+PBSWS      = 0.4                 PBSWD      = 0.4                 CJSWS      = 'cjswp_hvt'
+CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06                MJSWD      = 0.06
+PBSWGS     = 0.35                PBSWGD     = 0.35                CJSWGS     = 'cjswgp_hvt'
+CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9                 MJSWGD     = 0.9
+TPB        = 1.9E-03             TCJ        = 9.38E-04            TPBSW      = 1.6E-03
+TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     LETA0      = '0+dleta0p_hvt'     WETA0      = '0+dweta0p_hvt'
+LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.8 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17359026+dvthp_hvt'
+LVTH0      = '5.1307353e-010+dlvthp_hvt'
+WVTH0      = '3.2240573e-009+dwvthp_hvt'
+PVTH0      = '-4.6074003e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.019666992         LK2        = '-3.8140965e-010+dlk2p_hvt'
+WK2        = 7.8667989e-012      PK2        = -1.7600269e-018     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.080972106+dvoffp_hvt'
+LVOFF      = '-6.831831e-009+dlvoffp_hvt'
+WVOFF      = -1.3906014e-009     PVOFF      = '-8.6388756e-017+dpvoffp_hvt'
+NFACTOR    = 1.9752132           LNFACTOR   = -4.4906764e-008     WNFACTOR   = -4.6805439e-007
+PNFACTOR   = '-1.1518501e-014+dpnfactorp_hvt'
+ETA0       = 0.42                ETAB       = -0.02               U0         = '89.364236+du0p_hvt'
+LU0        = -4.6865145e-006     WU0        = -2.117116e-005      PU0        = '1.88612e-012+dpu0p_hvt'
+UA         = -6.6602086e-011     LUA        = -1.1853624e-016     WUA        = -1.0659485e-015
+PUA        = 6.3900058e-023      UB         = 2.7091956e-018      LUB        = -4.1139327e-026
+WUB        = -1.3933406e-027     PUB        = 2.9319653e-032      UC         = 3.4304974e-011
+LUC        = 3.3861827e-018      WUC        = 2.418043e-017       PUC        = -3.4555502e-024
+VSAT       = 160000              A0         = 8.0223574           LA0        = -2.3618255e-007
+WA0        = 2.7402822e-007      PA0        = '-8.3779355e-014+dpa0p_hvt'
+AGS        = -0.76016526         LAGS       = 1.6290922e-006      WAGS       = -2.6393037e-007
+PAGS       = -1.9657704e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.1192011
+LKETA      = -1.154672e-008      DWG        = 0                   DWB        = 0
+PCLM       = 1                   PDIBLC1    = 0                   PDIBLC2    = 0.0017099817
+LPDIBLC2   = 2.5602358e-011      WPDIBLC2   = 2.6095847e-009      PPDIBLC2   = -2.3037002e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052975004        LAIGC      = -2.8224176e-011     WAIGC      = -3.2240573e-011
+PAIGC      = 4.6074003e-018      BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.3146254          LKT1       = '2.5653677e-009+dlkt1p_hvt'
+WKT1       = -1.3806395e-008     PKT1       = '-2.3037002e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = 0.039118786         LKT2       = -1.1127987e-008
+WKT2       = -6.4513386e-008     PKT2       = 9.2194081e-015      UTE        = -0.84124969
+LUTE       = 4.088049e-008       WUTE       = -6.3239103e-007     PUTE       = 9.0371232e-014
+UA1        = 3.3614313e-009      LUA1       = 1.1978232e-016      WUA1       = -2.6832274e-015
+PUA1       = 2.2693796e-022      UB1        = -3.5483659e-018     LUB1       = -2.3682352e-025
+WUB1       = 2.2666149e-024      PUB1       = -8.7202654e-032     UC1        = -1.2847934e-010
+LUC1       = 6.9280323e-018      PRT        = 0                   AT         = 437589.03
+LAT        = '-0.032837733+dlatp_hvt'
+WAT        = -0.067591986        PAT        = '2.5340702e-008+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     LETA0      = '0+dleta0p_hvt'
+WETA0      = '0+dweta0p_hvt'     )

.MODEL pch_hvt.9 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.20704E-09        LL         = 4.38278E-03
+WL         = 0                   LLN        = -0.84142            WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.38278E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.20704E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16864336+dvthp_hvt'
+LVTH0      = '-1.938731e-010+dlvthp_hvt'
+K1         = 0.11                K2         = -0.0033633748       LK2        = '2.9097887e-009+dlk2p_hvt'
+WK2        = 1.2294245e-008      PK2        = -1.7575682e-015     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.11212259+dvoffp_hvt'
+LVOFF      = '-2.3802112e-009+dlvoffp_hvt'
+WVOFF      = -5.3784212e-009     PVOFF      = '4.8349822e-016+dpvoffp_hvt'
+NFACTOR    = 0.54182334          LNFACTOR   = 1.5993454e-007      WNFACTOR   = -2.4415801e-007
+PNFACTOR   = '-4.3514839e-014+dpnfactorp_hvt'
+ETA0       = 0.43582243          LETA0      = '-2.2611348e-009+dleta0p_hvt'
+WETA0      = '-2.0299855e-008+dweta0p_hvt'
+PETA0      = 2.9009893e-015      ETAB       = -0.020752014        LETAB      = 1.0746793e-010
+WETAB      = 6.7666182e-009      PETAB      = -9.6699643e-016     U0         = '63.93715+du0p_hvt'
+LU0        = -1.0528085e-006     WU0        = -1.0272843e-005     PU0        = '3.2867532e-013+dpu0p_hvt'
+UA         = -6.004465e-010      LUA        = -4.2246186e-017     WUA        = -9.6659986e-016
+PUA        = 4.9702447e-023      UB         = 2.4176794e-018      LUB        = 5.2035088e-028
+WUB        = 4.8617014e-025      PUB        = -4.0356532e-032     UC         = 5.8e-011
+VSAT       = 160000              A0         = 7.6965343           LA0        = -1.8962018e-007
+WA0        = -4.1035511e-006     PA0        = '5.4180694e-013+dpa0p_hvt'
+AGS        = 4.2901053           LAGS       = 9.0737367e-007      WAGS       = -6.7382247e-007
+PAGS       = 3.8918705e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.20909943
+LKETA      = 1.3003715e-009      WKETA      = -4.0193712e-008     PKETA      = 5.7439588e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1.3391598
+LPCLM      = -4.8468276e-008     PDIBLC1    = 0                   PDIBLC2    = 0.002492254
+LPDIBLC2   = -8.6189758e-011     WPDIBLC2   = 1.6742179e-009      PPDIBLC2   = -9.6699643e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0051716071        LAIGC      = -1.0233149e-011     WAIGC      = 2.7066473e-011
+PAIGC      = -3.8679857e-018     BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.2559749          LKT1       = '-5.8161931e-009+dlkt1p_hvt'
+WKT1       = -2.9926681e-008     PKT1       = '1.4534095e-029+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.037715981        LKT2       = -1.477684e-010
+WKT2       = -9.3041e-009        PKT2       = 1.3296201e-015      UTE        = -0.66114435
+LUTE       = 1.5142195e-008      WUTE       = 1.545283e-007       PUTE       = -2.208497e-014
+UA1        = 5.3342679e-009      LUA1       = -1.6214965e-016     WUA1       = -1.4970829e-015
+PUA1       = 5.7429725e-023      UB1        = -7.410454e-018      LUB1       = 3.1509552e-025
+WUB1       = 2.5296187e-024      PUB1       = -1.247877e-031      UC1        = -8.3008054e-011
+LUC1       = 4.2987172e-019      WUC1       = 2.7066473e-017      PUC1       = -3.8679857e-024
+PRT        = 0                   AT         = 225161.55           LAT        = '-0.002480379+dlatp_hvt'
+WAT        = 0.1976972           PAT        = '-1.2570954e-008+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     )

.MODEL pch_hvt.10 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '9e-007-dxw_hvt'    WMAX       = '9e-006-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.606405E-09       LL         = 5.48932E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.48932E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.606405E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.18767283+dvthp_hvt'
+LVTH0      = '9.0523299e-010+dlvthp_hvt'
+WVTH0      = '1.4074203e-008+dwvthp_hvt'
+PVTH0      = '-8.1289922e-016+dpvthp_hvt'
+K1         = 0.11                K2         = -0.012508486        LK2        = '3.437993e-009+dlk2p_hvt'
+WK2        = -1.1728833e-007     PK2        = 5.726875e-015       K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '0.091590676+dvoffp_hvt'
+LVOFF      = '-1.4146303e-008+dlvoffp_hvt'
+WVOFF      = -7.4415448e-008     PVOFF      = '4.4709457e-015+dpvoffp_hvt'
+NFACTOR    = -4.6053267          LNFACTOR   = 4.5722415e-007      WNFACTOR   = 4.0986425e-007
+PNFACTOR   = '-8.1289922e-014+dpnfactorp_hvt'
+ETA0       = 0.17331271          LETA0      = '1.2900928e-008+dleta0p_hvt'
+WETA0      = '1.354832e-007+dweta0p_hvt'
+PETA0      = -6.0967442e-015     ETAB       = -0.018891358        WETAB      = -9.9755605e-009
+U0         = '60.056413+du0p_hvt'
+LU0        = -8.2866447e-007     WU0        = -6.0047039e-005     PU0        = '3.2035383e-012+dpu0p_hvt'
+UA         = -2.6770453e-010     LUA        = -6.146473e-017      WUA        = -1.6096615e-015
+PUA        = 8.6844463e-023      UB         = 2.7218565e-018      LUB        = -1.7048342e-026
+WUB        = -1.0255672e-024     PUB        = 4.6958546e-032      UC         = 4.7050965e-011
+LUC        = 6.3239548e-019      WUC        = 9.8519421e-017      PUC        = -5.6902946e-024
+VSAT       = 257955.2            LVSAT      = '-0.0056577062+dlvsatp_hvt'
+WVSAT      = -0.087963769        PVSAT      = '5.0806201e-009+dpvsatp_hvt'
+A0         = -2.7542143          LA0        = 4.139952e-007       WA0        = 6.2974512e-006
+PA0        = '-5.8935194e-014+dpa0p_hvt'
+AGS        = 21.571986           LAGS       = -9.0794929e-008     WAGS       = 1.7592754e-005
+PAGS       = -1.016124e-012      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.33525829
+LKETA      = 8.5870675e-009      WKETA      = 1.2751471e-007      PKETA      = -3.9425612e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 0.45698593
+LPCLM      = 2.4844108e-009      WPCLM      = 3.8704058e-007      PPCLM      = '-2.2354729e-014+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0049944346
+WAIGC      = -3.9902242e-011     BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041888914        WAIGSD     = 9.9755605e-012      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.24956861         LKT1       = '-6.1862081e-009+dlkt1p_hvt'
+WKT1       = -2.0022454e-007     PKT1       = '9.8360806e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.045651141        LKT2       = 3.1055135e-010
+WKT2       = 6.2096468e-008      PKT2       = -2.7943411e-015     UTE        = -0.21172172
+LUTE       = -1.0815603e-008     WUTE       = -5.6136525e-008     PUTE       = -9.9173705e-015
+UA1        = 6.6325017e-009      LUA1       = -2.3713317e-016     WUA1       = -2.0896346e-015
+PUA1       = 9.1654387e-023      UB1        = -6.2231583e-018     LUB1       = 2.4651957e-025
+WUB1       = 2.4788188e-024      PUB1       = -1.2185359e-031     UC1        = -1.6042115e-010
+LUC1       = 4.9011052e-018      WUC1       = -5.4586984e-016     PUC1       = 2.9223727e-023
+PRT        = 0                   AT         = 260581.44           LAT        = '-0.0045261649+dlatp_hvt'
+WAT        = -0.090322136        PAT        = '4.0644961e-009+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_hvt.11 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp_hvt'          TOXM       = 2.13e-009           DTOX       = 6.3e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16851667+dvthp_hvt'
+WVTH0      = '-4.0260333e-009+dwvthp_hvt'
+K1         = 0.11                K2         = 0.014450556         WK2        = 1.3420111e-010
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.095429556+dvoffp_hvt'
+WVOFF      = -2.3082591e-009     NFACTOR    = 1.1911493           WNFACTOR   = -1.7165208e-007
+ETA0       = 0.42                ETAB       = -0.02               U0         = '58.135688+du0p_hvt'
+LU0        = 5.2769882e-009      WU0        = 1.9634153e-005      PU0        = '-4.7387354e-015+dpu0p_hvt'
+UA         = -1.7656409e-009     LUA        = 6.8063065e-020      WUA        = 8.1326557e-016
+PUA        = -6.1120632e-026     UB         = 3.6182147e-018      LUB        = 5.1425427e-028
+WUB        = -7.7965681e-025     PUB        = -4.6180033e-034     UC         = -2.4166667e-012
+WUC        = 2.0130167e-017      VSAT       = 160000              A0         = 9.0983874
+LA0        = 8.0831644e-010      WA0        = -6.0922123e-007     PA0        = '-4.6330948e-016+dpa0p_hvt'
+AGS        = 0.54352636          LAGS       = 1.4000097e-006      WAGS       = 3.7565926e-008
+PAGS       = -9.5897517e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = 0.037057124
+LKETA      = -1.8685265e-007     WKETA      = -7.2473214e-008     PKETA      = 7.2393993e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.4
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055481428
+LAIGC      = -2.9781691e-010     WAIGC      = -4.5324086e-011     PAIGC      = 4.5274542e-017
+BIGC       = 0.00099270438       LBIGC      = -3.9134154e-014     CIGC       = 1e-010
+AIGSD      = 0.0041814415        LAIGSD     = -5.6102283e-011     WAIGSD     = 3.6884498e-011
+PAIGSD     = 3.0183028e-017      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.32393985         LKT1       = '5.8819932e-008+dlkt1p_hvt'
+WKT1       = 3.9457989e-008      PKT1       = '-5.2820299e-014+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.23722119
+LUTE       = -1.2131338e-011     WUTE       = -3.7042558e-007     PUTE       = 3.0484858e-017
+UA1        = 2.411786e-009       LUA1       = 1.1627292e-018      WUA1       = 1.8001929e-015
+PUA1       = -5.5536772e-025     UB1        = -2.0233837e-018     LUB1       = 8.9525405e-025
+WUB1       = -2.9752463e-024     PUB1       = -8.0431884e-031     UC1        = -1.1e-010
+PRT        = 0                   AT         = 203649.22           LAT        = '0.1461908+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LK2        = '0+dlk2p_hvt'       LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'
+LVOFF      = '0+dlvoffp_hvt'     PVOFF      = '0+dpvoffp_hvt'     LETA0      = '0+dleta0p_hvt'
+WETA0      = '0+dweta0p_hvt'     PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.12 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16942122+dvthp_hvt'
+LVTH0      = '9.0356759e-010+dlvthp_hvt'
+WVTH0      = '-4.8323302e-009+dwvthp_hvt'
+PVTH0      = '8.0541547e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.010441209         LK2        = '4.0049644e-009+dlk2p_hvt'
+WK2        = 1.5477846e-009      PK2        = -1.4120383e-015     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.092082764+dvoffp_hvt'
+LVOFF      = '-3.3431334e-009+dlvoffp_hvt'
+WVOFF      = -3.6950897e-009     PVOFF      = '1.3853146e-015+dpvoffp_hvt'
+NFACTOR    = 1.1257505           LNFACTOR   = 6.5327352e-008      WNFACTOR   = -2.7478277e-007
+PNFACTOR   = '1.0301795e-013+dpnfactorp_hvt'
+ETA0       = 0.42                ETAB       = -0.02               U0         = '62.20051+du0p_hvt'
+LU0        = -4.0551025e-006     WU0        = 2.7373301e-005      PU0        = '-7.7354277e-012+dpu0p_hvt'
+UA         = -2.0162037e-009     LUA        = 2.5035695e-016      WUA        = 1.3188263e-015
+PUA        = -5.050692e-022      UB         = 4.245271e-018       LUB        = -6.2585663e-025
+WUB        = -1.307684e-024      PUB        = 5.2698818e-031      UC         = -3.991737e-011
+LUC        = 3.7459712e-017      WUC        = 3.2224619e-017      PUC        = -1.2081232e-023
+VSAT       = 160000              A0         = 9.8675548           LA0        = -7.6751837e-007
+WA0        = -7.7547741e-007     PA0        = '1.6561114e-013+dpa0p_hvt'
+AGS        = 1.3663111           LAGS       = 5.7812432e-007      WAGS       = -2.6862441e-007
+PAGS       = 2.0995812e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.15
+DWG        = 0                   DWB        = 0                   PCLM       = 0.039512596
+LPCLM      = 3.6009336e-007      PDIBLC1    = 0                   PDIBLC2    = -0.0025981983
+LPDIBLC2   = 3.5942652e-009      WPDIBLC2   = 1.6125937e-009      PPDIBLC2   = -1.6108309e-015
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052531042        LAIGC      = -3.1008039e-012     WAIGC      = 2.4188905e-011
+PAIGC      = -2.4162464e-017     BIGC       = 0.00099264429       LBIGC      = 2.0885415e-014
+CIGC       = 1e-010              AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010
+NTOX       = 'ntoxp_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'          CGBO       = 0
+CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 1.827               VOFFCV     = -0.03               KT1        = -0.21705733
+LKT1       = '-4.7945763e-008+dlkt1p_hvt'
+WKT1       = -2.9546048e-008     PKT1       = '1.6108309e-014+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.0050578459       LKT2       = -3.3655325e-008
+WKT2       = -3.2267999e-008     PKT2       = 3.2232727e-014      UTE        = 0.87211425
+LUTE       = -1.108135e-006      WUTE       = -1.0869511e-006     PUTE       = 7.1577273e-013
+UA1        = 5.1899981e-009      LUA1       = -2.7740125e-015     WUA1       = 9.5141263e-016
+PUA1       = 8.4729708e-022      UB1        = -2.2807598e-018     LUB1       = 1.1523487e-024
+WUB1       = -4.5907736e-024     PUB1       = 8.0944255e-031      UC1        = -1.1e-010
+PRT        = 0                   AT         = 350000              JSS        = 1.4E-07
+JSD        = 1.4E-07             JSWS       = 6.00E-13            JSWD       = 6.00E-13
+JSWGS      = 1.12E-12            JSWGD      = 1.12E-12            NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_hvt'
+CJD        = 'cjp_hvt'           MJS        = 0.35                MJD        = 0.35
+PBSWS      = 0.4                 PBSWD      = 0.4                 CJSWS      = 'cjswp_hvt'
+CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06                MJSWD      = 0.06
+PBSWGS     = 0.35                PBSWGD     = 0.35                CJSWGS     = 'cjswgp_hvt'
+CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9                 MJSWGD     = 0.9
+TPB        = 1.9E-03             TCJ        = 9.38E-04            TPBSW      = 1.6E-03
+TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04             TCJSWG     = 5.5E-03
+XTIS       = 3                   XTID       = 3                   DMCG       = 9.65e-8
+DMCI       = 9.65e-8             DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'     PVSAT      = '0+dpvsatp_hvt'
+PPCLM      = '0+dppclmp_hvt'     LETA0      = '0+dleta0p_hvt'     WETA0      = '0+dweta0p_hvt'
+LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.13 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16517002+dvthp_hvt'
+LVTH0      = '-6.9023729e-010+dlvthp_hvt'
+WVTH0      = '-4.3373209e-009+dwvthp_hvt'
+PVTH0      = '6.1983309e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.018151247         LK2        = '1.1144177e-009+dlk2p_hvt'
+WK2        = 1.3690061e-009      PK2        = -1.345013e-015      K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.08067957+dvoffp_hvt'
+LVOFF      = '-7.6182696e-009+dlvoffp_hvt'
+WVOFF      = -1.6532987e-009     PVOFF      = '6.1983309e-016+dpvoffp_hvt'
+NFACTOR    = 1.4079673           LNFACTOR   = -4.047767e-008      WNFACTOR   = 4.1332467e-008
+PNFACTOR   = '-1.5495827e-014+dpnfactorp_hvt'
+ETA0       = 0.42                ETAB       = -0.02               U0         = '59.318776+du0p_hvt'
+LU0        = -2.9747204e-006     WU0        = 5.8096636e-006      PU0        = '3.4892884e-013+dpu0p_hvt'
+UA         = -1.0662075e-009     LUA        = -1.0580318e-016     WUA        = -1.6830285e-016
+PUA        = 5.2465772e-023      UB         = 2.5136394e-018      LUB        = 2.3344019e-026
+WUB        = 1.7421612e-025      PUB        = -2.8586392e-032     UC         = 6.1231956e-011
+LUC        = -4.6186882e-019     VSAT       = 160000              A0         = 9.7440098
+LA0        = -7.2120048e-007     WA0        = -1.2720156e-006     PA0        = '3.5176674e-013+dpa0p_hvt'
+AGS        = -1.7863604          LAGS       = 1.7600826e-006      WAGS       = 6.575929e-007
+PAGS       = -1.3728714e-013     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.091584751
+LKETA      = -2.190028e-008      WKETA      = -2.479948e-008      PKETA      = 9.2974963e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1
+PDIBLC1    = 0                   PDIBLC2    = 0.0089856843        LPDIBLC2   = -7.4861238e-010
+WPDIBLC2   = -3.9239962e-009     PPDIBLC2   = 4.6487481e-016      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0052880202
+LAIGC      = -1.6191068e-011     WAIGC      = -2.3727346e-011     PAIGC      = -6.1983309e-018
+BIGC       = 0.0009927           CIGC       = 1e-010              AIGSD      = 0.0041252778
+WAIGSD     = 6.7100556e-011      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9
+NTOX       = 'ntoxp_hvt'         XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'          CGBO       = 0
+CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'          CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_hvt'           CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.5                 MOIN       = 16.73
+NOFF       = 1.827               VOFFCV     = -0.03               KT1        = -0.34494444
+WKT1       = 1.3420111e-008      KT1L       = 0                   KT2        = -0.12937028
+LKT2       = 1.2950263e-008      WKT2       = 8.6789791e-008      PKT2       = -1.240286e-014
+UTE        = -3.3145546          LUTE       = 4.614761e-007       WUTE       = 1.5886368e-006
+PUTE       = -2.8732363e-013     UA1        = -6.3998306e-009     LUA1       = 1.5710943e-015
+WUA1       = 6.0823858e-015      PUA1       = -1.0763402e-021     UB1        = 4.3384891e-018
+LUB1       = -1.3292533e-024     WUB1       = -4.8157808e-024     PUB1       = 8.9379931e-031
+UC1        = -1.2847934e-010     LUC1       = 6.9280323e-018      PRT        = 0
+AT         = 362319.56           LAT        = '-0.0046186882+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     LETA0      = '0+dleta0p_hvt'
+WETA0      = '0+dweta0p_hvt'     LKT1       = '0+dlkt1p_hvt'      PKT1       = '0+dpkt1p_hvt'
+PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.14 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.20704E-09        LL         = 4.38278E-03
+WL         = 0                   LLN        = -0.84142            WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.38278E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.20704E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16560223+dvthp_hvt'
+LVTH0      = '-6.2847197e-010+dlvthp_hvt'
+WVTH0      = '-2.7309373e-009+dwvthp_hvt'
+PVTH0      = '3.9026979e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.029596259         LK2        = '-5.2115346e-010+dlk2p_hvt'
+WK2        = -1.7303506e-008     PK2        = 1.3234179e-015      K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.12718308+dvoffp_hvt'
+LVOFF      = '-9.7259673e-010+dlvoffp_hvt'
+WVOFF      = 8.1458969e-009      PVOFF      = '-7.8053957e-016+dpvoffp_hvt'
+NFACTOR    = 1.1049379           LNFACTOR   = 2.8273161e-009      WNFACTOR   = -7.4983489e-007
+PNFACTOR   = '9.7567447e-014+dpnfactorp_hvt'
+ETA0       = 0.23074883          LETA0      = '2.7045298e-008+dleta0p_hvt'
+WETA0      = '1.6385624e-007+dweta0p_hvt'
+PETA0      = -2.3416187e-014     ETAB       = -0.0030796944       LETAB      = -2.4180284e-009
+WETAB      = -9.1031244e-009     PETAB      = 1.3008993e-015      U0         = '36.461345+du0p_hvt'
+LU0        = 2.9176424e-007      WU0        = 1.440043e-005       PU0        = '-8.7875097e-013+dpu0p_hvt'
+UA         = -2.3637057e-009     LUA        = 7.9618267e-017      WUA        = 6.1680692e-016
+PUA        = -5.9731832e-023     UB         = 3.3195519e-018      LUB        = -9.1826443e-026
+WUB        = -3.2371142e-025     PUB        = 4.2570889e-032      UC         = 3.9753203e-011
+LUC        = 2.6075932e-018      WUC        = 1.6385624e-017      PUC        = -2.3416187e-024
+VSAT       = 160000              A0         = -0.40391746         LA0        = 7.2900834e-007
+WA0        = 3.1706545e-006      PA0        = '-2.8312148e-013+dpa0p_hvt'
+AGS        = 4.1061931           LAGS       = 9.1799609e-007      WAGS       = -5.0866926e-007
+PAGS       = 2.937977e-014       A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.38931767
+LKETA      = 2.0647809e-008      WKETA      = 1.2164227e-007      PKETA      = -1.163004e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 1.3391598
+LPCLM      = -4.8468276e-008     PDIBLC1    = 0                   PDIBLC2    = 0.0056107169
+LPDIBLC2   = -2.6630625e-010     WPDIBLC2   = -1.1261618e-009     PPDIBLC2   = 6.5044964e-017
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0052866073        LAIGC      = -1.5989146e-011     WAIGC      = -7.620368e-011
+PAIGC      = 1.3008993e-018      BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.27383394         LKT1       = '-1.0162182e-008+dlkt1p_hvt'
+WKT1       = -1.3889262e-008     PKT1       = '3.9026979e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.06201542         LKT2       = 3.3247891e-009
+WKT2       = 1.2516796e-008      PKT2       = -1.7887365e-015     UTE        = 0.36204619
+LUTE       = -6.3935526e-008     WUTE       = -7.642968e-007      PUTE       = 4.8926822e-014
+UA1        = 6.1985462e-009      LUA1       = -2.2930072e-016     WUA1       = -2.2732048e-015
+PUA1       = 1.1773139e-022      UB1        = -7.199125e-018      LUB1       = 3.1955134e-025
+WUB1       = 2.3398452e-024      PUB1       = -1.2878903e-031     UC1        = -1.2318778e-011
+LUC1       = -9.6721137e-018     WUC1       = -3.6412498e-017     PUC1       = 5.2035972e-024
+PRT        = 0                   AT         = 455451.44           LAT        = '-0.017927877+dlatp_hvt'
+WAT        = -0.0091031244       PAT        = '1.3008993e-009+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     )

.MODEL pch_hvt.15 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '5.4e-007-dxw_hvt'  WMAX       = '9e-007-dxw_hvt'    VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.606405E-09       LL         = 5.48932E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.48932E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.606405E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17121217+dvthp_hvt'
+LVTH0      = '-3.0445225e-010+dlvthp_hvt'
+WVTH0      = '-7.074693e-010+dwvthp_hvt'
+PVTH0      = '2.7339812e-016+dpvthp_hvt'
+K1         = 0.11                K2         = -0.25046674         LK2        = '1.5654754e-008+dlk2p_hvt'
+WK2        = 9.6398187e-008      PK2        = -5.2437759e-015     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '0.019971633+dvoffp_hvt'
+LVOFF      = '-9.4719735e-009+dlvoffp_hvt'
+WVOFF      = -1.0101547e-008     PVOFF      = '2.7339812e-016+dpvoffp_hvt'
+NFACTOR    = -5.722135           LNFACTOR   = 3.9714607e-007      WNFACTOR   = 1.412758e-006
+PNFACTOR   = '-2.7339812e-014+dpnfactorp_hvt'
+ETA0       = 1.4497485           LETA0      = '-4.3361809e-008+dleta0p_hvt'
+WETA0      = '-1.0107562e-006+dweta0p_hvt'
+PETA0      = 4.4427194e-014      ETAB       = -0.097656055        LETAB      = 3.0445225e-009
+WETAB      = 6.0755137e-008      PETAB      = -2.7339812e-015     U0         = '-63.062703+du0p_hvt'
+LU0        = 6.0400841e-006      WU0        = 5.0513928e-005      PU0        = '-2.964598e-012+dpu0p_hvt'
+UA         = -9.2071974e-010     LUA        = -3.7258617e-018     WUA        = -1.0232538e-015
+PUA        = 3.4994959e-023      UB         = -2.7864401e-018     LUB        = 2.6084406e-025
+WUB        = 3.9208831e-024      PUB        = -2.0258883e-031     UC         = 2.2583008e-010
+LUC        = -8.1398534e-018     WUC        = -6.2024221e-017     PUC        = 2.1871849e-024
+VSAT       = 160000              A0         = -0.71885003         LA0        = 7.4719825e-007
+WA0        = 4.4696941e-006      PA0        = '-3.5815154e-013+dpa0p_hvt'
+AGS        = 4.2648984           LAGS       = 9.0882957e-007      WAGS       = 3.3134518e-005
+PAGS       = -1.9137868e-012     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = 0.31404047
+LKETA      = -1.9976821e-008     WKETA      = -4.5555557e-007     PKETA      = 2.1707811e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.94070042
+LPCLM      = -2.5454019e-008     WPCLM      = -4.7335026e-008     PPCLM      = '2.7339812e-015+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.0062711611        LPDIBLC2   = -3.0445225e-010
+WPDIBLC2   = -4.7335026e-009     PPDIBLC2   = 2.7339812e-016      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0050097778
+WAIGC      = -5.3680444e-011     BIGC       = 0.0009927           CIGC       = 1e-010
+AIGSD      = 0.0041252778        WAIGSD     = 6.7100556e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.78743777         LKT1       = '1.95026e-008+dlkt1p_hvt'
+WKT1       = 2.8278197e-007      PKT1       = '-1.3232469e-014+dpkt1p_hvt'
+KT1L       = 0                   KT2        = 0.11652568          LKT2       = -6.9874054e-009
+WKT2       = -8.3538314e-008     PKT2       = 3.7592241e-015      UTE        = 0.19915381
+LUTE       = -5.4527171e-008     WUTE       = -4.2510275e-007     PUTE       = 2.9335618e-014
+UA1        = 6.2696272e-009      LUA1       = -2.3340622e-016     WUA1       = -1.7637733e-015
+PUA1       = 8.8307592e-023      UB1        = -6.4528371e-018     LUB1       = 2.7644717e-025
+WUB1       = 2.6850703e-024      PUB1       = -1.4872858e-031     UC1        = -1.7969112e-009
+LUC1       = 9.3402554e-017      WUC1       = 9.2369823e-016      PUC1       = -5.0250574e-023
+PRT        = 0                   AT         = 145055.56           WAT        = 0.013420111
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.16 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp_hvt'          TOXM       = 2.13e-009           DTOX       = 6.3e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17666049+dvthp_hvt'
+WVTH0      = '3.5534568e-010+dwvthp_hvt'
+K1         = 0.11                K2         = 0.014501852         WK2        = 1.066037e-010
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.10349802+dvoffp_hvt'
+WVOFF      = 2.0325773e-009      NFACTOR    = 0.3252662           WNFACTOR   = 2.9419303e-007
+ETA0       = 0.49925926          WETA0      = '-4.2641481e-008+dweta0p_hvt'
+ETAB       = -0.013395062        WETAB      = -3.5534568e-009     U0         = '94.544757+du0p_hvt'
+LU0        = -5.5513632e-009     WU0        = 4.6073371e-008      PU0        = '1.0869177e-015+dpu0p_hvt'
+UA         = 5.6510079e-011      LUA        = -1.0667278e-019     WUA        = -1.6705168e-016
+PUA        = 3.2887251e-026      UB         = 1.7522923e-018      LUB        = -5.7139363e-028
+WUB        = 2.2420945e-025      PUB        = 1.2227824e-034      UC         = -7.9320988e-012
+WUC        = 2.3097469e-017      VSAT       = 160000              A0         = 8.8140809
+LA0        = -6.1023901e-011     WA0        = -4.5626434e-007     PA0        = '4.3956229e-018+dpa0p_hvt'
+AGS        = 0.37262761          LAGS       = 1.1299942e-006      WAGS       = 1.2950945e-007
+PAGS       = 4.9370837e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.10572042
+LKETA      = -2.4438021e-008     WKETA      = 4.3411058e-009      PKETA      = -1.4985078e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.4
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0055241725
+LAIGC      = -2.2109103e-010     WAIGC      = -3.2428048e-011     PAIGC      = 3.9960208e-018
+BIGC       = 0.0010044681        LBIGC      = -1.0152556e-013     WBIGC      = -6.3289074e-012
+PBIGC      = 3.3566575e-020      CIGC       = 1e-010              AIGSD      = 0.0042301852
+WAIGSD     = 1.066037e-011       BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.24769029         LKT1       = '-6.5355481e-008+dlkt1p_hvt'
+WKT1       = -1.564279e-009      PKT1       = '1.3986073e-014+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.84204561
+LUTE       = 4.2601083e-010      WUTE       = -4.5030045e-008     PUTE       = -2.0523563e-016
+UA1        = 6.4292063e-009      LUA1       = -1.443721e-019      WUA1       = -3.6117922e-016
+PUA1       = 1.4785277e-025      UB1        = -8.9593794e-018     LUB1       = -9.9601836e-025
+WUB1       = 7.5631936e-025      PUB1       = 2.1318571e-031      UC1        = -1.1e-010
+PRT        = 0                   AT         = 203649.22           LAT        = '0.1461908+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LK2        = '0+dlk2p_hvt'       LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'
+LVOFF      = '0+dlvoffp_hvt'     PVOFF      = '0+dpvoffp_hvt'     LETA0      = '0+dleta0p_hvt'
+PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.17 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17946058+dvthp_hvt'
+LVTH0      = '2.7970214e-009+dlvthp_hvt'
+WVTH0      = '5.6884175e-010+dwvthp_hvt'
+PVTH0      = '-2.132627e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.010223104         LK2        = '4.274071e-009+dlk2p_hvt'
+WK2        = 1.665125e-009       PK2        = -1.5568177e-015     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.1042052+dvoffp_hvt'
+LVOFF      = '7.0640536e-010+dlvoffp_hvt'
+WVOFF      = 2.8267827e-009      PVOFF      = '-7.9333723e-016+dpvoffp_hvt'
+NFACTOR    = -0.11353774         LNFACTOR   = 4.3832429e-007      WNFACTOR   = 3.9195429e-007
+PNFACTOR   = '-9.7654396e-014+dpnfactorp_hvt'
+ETA0       = 0.49925926          WETA0      = '-4.2641481e-008+dweta0p_hvt'
+ETAB       = -0.013395062        WETAB      = -3.5534568e-009     U0         = '121.4166+du0p_hvt'
+LU0        = -2.6848024e-005     WU0        = -4.4849566e-006     PU0        = '4.527164e-012+dpu0p_hvt'
+UA         = 1.1450698e-009      LUA        = -1.0874765e-015     WUA        = -3.8193889e-016
+PUA        = 2.146852e-022       UB         = 8.3244657e-019      LUB        = 9.1826886e-025
+WUB        = 5.2841559e-025      PUB        = -3.0375134e-031     UC         = -4.8746542e-011
+LUC        = 4.0769829e-017      WUC        = 3.6974714e-017      PUC        = -1.3862075e-023
+VSAT       = 160000              A0         = 10.955539           LA0        = -2.1391779e-006
+WA0        = -1.3608127e-006     PA0        = '9.0356397e-013+dpa0p_hvt'
+AGS        = 0.044904431         LAGS       = 1.4573591e-006      WAGS       = 4.4229239e-007
+PAGS       = -2.630702e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.082565244
+LKETA      = -4.7567888e-008     WKETA      = -3.6279899e-008     PKETA      = 2.5591524e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.039512596
+LPCLM      = 3.6009336e-007      PDIBLC1    = 0                   PDIBLC2    = 0.001986519
+LPDIBLC2   = -9.8544066e-010     WPDIBLC2   = -8.5398428e-010     PPDIBLC2   = 8.5305079e-016
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0053628095        LAIGC      = -5.9904419e-011     WAIGC      = -3.4832536e-011
+PAIGC      = 6.3978809e-018      BIGC       = 0.0010043123        LBIGC      = 5.4182936e-014
+WBIGC      = -6.2773704e-012     PBIGC      = -1.7914066e-020     CIGC       = 1e-010
+AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011       BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.8993917           LPIGCD     = 2.2805912e-010      NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.30104541         LKT1       = '-1.2058682e-008+dlkt1p_hvt'
+WKT1       = 1.563954e-008       PKT1       = '-3.1989404e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.06503554         LKT2       = 2.6256807e-008
+UTE        = -1.0136432          LUTE       = 1.7183603e-007      WUTE       = -7.2413554e-008
+PUTE       = 2.7148341e-014      UA1        = 8.2072734e-009      LUA1       = -1.7762679e-015
+WUA1       = -6.7188149e-016     PUA1       = 3.1051049e-022      UB1        = -1.3797655e-017
+LUB1       = 3.8369688e-024      WUB1       = 1.6053162e-024      PUB1       = -6.3488305e-031
+UC1        = -1.1e-010           PRT        = 0                   AT         = 350000
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     LETA0      = '0+dleta0p_hvt'
+LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.18 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17567305+dvthp_hvt'
+LVTH0      = '1.3770533e-009+dlvthp_hvt'
+WVTH0      = '1.3133108e-009+dwvthp_hvt'
+PVTH0      = '-4.9236927e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.024505626         LK2        = '-1.080545e-009+dlk2p_hvt'
+WK2        = -2.0496495e-009     PK2        = -1.6412309e-016     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.085277028+dvoffp_hvt'
+LVOFF      = '-6.3898981e-009+dlvoffp_hvt'
+WVOFF      = 8.2013392e-010      PVOFF      = '-4.1030772e-017+dpvoffp_hvt'
+NFACTOR    = 1.1305613           LNFACTOR   = -2.809702e-008      WNFACTOR   = 1.9057689e-007
+PNFACTOR   = '-2.2156617e-014+dpnfactorp_hvt'
+ETA0       = 0.49925926          WETA0      = '-4.2641481e-008+dweta0p_hvt'
+ETAB       = -0.013395062        WETAB      = -3.5534568e-009     U0         = '56.753449+du0p_hvt'
+LU0        = -2.6053613e-006     WU0        = 7.1898094e-006      PU0        = '1.5021366e-013+dpu0p_hvt'
+UA         = -1.7749365e-009     LUA        = 7.2540083e-018      WUA        = 2.1299333e-016
+PUA        = -8.3589941e-024     UB         = 3.5951481e-018      LUB        = -1.1748703e-025
+WUB        = -4.0763559e-025     PUB        = 4.718071e-032       UC         = 6.4079904e-011
+LUC        = -1.5295841e-018     WUC        = -1.5321959e-018     PUC        = 5.7443081e-025
+VSAT       = 160000              A0         = 4.5029946           LA0        = 2.7992535e-007
+WA0        = 1.5476505e-006      PA0        = '-1.8683896e-013+dpa0p_hvt'
+AGS        = -0.17815998         LAGS       = 1.5409875e-006      WAGS       = -2.0761894e-007
+PAGS       = -1.9413956e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.20729613
+LKETA      = -8.0541939e-010     WKETA      = 3.7453239e-008      PKETA      = -2.0515386e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 0.91863006
+LPCLM      = 3.050615e-008       WPCLM      = 4.3777025e-008      PPCLM      = '-1.6412309e-014+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = -0.0029842127       LPDIBLC2   = 8.7812096e-010
+WPDIBLC2   = 2.5158084e-009      PPDIBLC2   = -4.1030772e-016     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.00530949
+LAIGC      = -3.9914589e-011     WAIGC      = -3.5278094e-011     PAIGC      = 6.5649235e-018
+BIGC       = 0.0010044568        WBIGC      = -6.3251531e-012     CIGC       = 1e-010
+AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011       BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.33727837         LKT1       = '1.5253075e-009+dlkt1p_hvt'
+WKT1       = 9.2957648e-009      PKT1       = '-8.2061544e-016+dpkt1p_hvt'
+KT1L       = 0                   KT2        = 0.031949038         LKT2       = -1.010338e-008
+UTE        = -0.43590749         LUTE       = -4.4761076e-008     WUTE       = 3.9924647e-008
+PUTE       = -1.4968026e-014     UA1        = 4.3433262e-009      LUA1       = -3.2764746e-016
+WUA1       = 3.0256736e-016      PUA1       = -5.4817112e-023     UB1        = -4.2829793e-018
+LUB1       = 2.6985113e-025      WUB1       = -1.7743086e-025     PUB1       = 3.348111e-032
+UC1        = -1.2847934e-010     LUC1       = 6.9280323e-018      PRT        = 0
+AT         = 337908.58           LAT        = '0.0045331569+dlatp_hvt'
+WAT        = 0.013133108         PAT        = '-4.9236927e-009+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     LETA0      = '0+dleta0p_hvt'     )

.MODEL pch_hvt.19 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.20704E-09        LL         = 4.38278E-03
+WL         = 0                   LLN        = -0.84142            WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.38278E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.20704E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16761141+dvthp_hvt'
+LVTH0      = '2.2498854e-010+dlvthp_hvt'
+WVTH0      = '-1.6499982e-009+dwvthp_hvt'
+PVTH0      = '-6.8891969e-017+dpvthp_hvt'
+K1         = 0.11                K2         = 0.0015859488        LK2        = '2.194835e-009+dlk2p_hvt'
+WK2        = -2.2339594e-009     PK2        = -1.3778394e-016     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.11280874+dvoffp_hvt'
+LVOFF      = '-2.4554268e-009+dlvoffp_hvt'
+WVOFF      = 4.1249955e-010      PVOFF      = '1.7222992e-017+dpvoffp_hvt'
+NFACTOR    = -0.67161094         LNFACTOR   = 2.2944583e-007      WNFACTOR   = 2.0594839e-007
+PNFACTOR   = '-2.4353311e-014+dpnfactorp_hvt'
+ETA0       = 0.68177748          LETA0      = '-2.6083113e-008+dleta0p_hvt'
+WETA0      = '-7.8797172e-008+dweta0p_hvt'
+PETA0      = 5.1668977e-015      ETAB       = -0.013395062        WETAB      = -3.5534568e-009
+U0         = '51.059239+du0p_hvt'
+LU0        = -1.7916195e-006     WU0        = 6.5467628e-006      PU0        = '2.4210946e-013+dpu0p_hvt'
+UA         = -1.3500064e-009     LUA        = -5.347144e-017      WUA        = 7.1436664e-017
+PUA        = 1.1870431e-023      UB         = 2.9107422e-018      LUB        = -1.9680688e-026
+WUB        = -1.0377176e-025     PUB        = 3.7564724e-033      UC         = 6.6930374e-011
+LUC        = -1.9369359e-018     WUC        = 1.7643059e-018      PUC        = 1.0333795e-025
+VSAT       = 164480.26           LVSAT      = '-0.00064025994+dlvsatp_hvt'
+WVSAT      = -0.0024103794       PVSAT      = '3.4445985e-010+dpvsatp_hvt'
+A0         = 5.636124            LA0        = 1.1799335e-007      WA0        = -7.8887751e-008
+PA0        = '4.5604589e-014+dpa0p_hvt'
+AGS        = 4.232182            LAGS       = 9.1071921e-007      WAGS       = -5.7645128e-007
+PAGS       = 3.3294731e-014      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.23079033
+LKETA      = 2.5520641e-009      WKETA      = 3.6354556e-008      PKETA      = -1.8945292e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1.4712586
+LPCLM      = -4.8468276e-008     WPCLM      = -7.1069136e-008     PPCLM      = '1.8442317e-029+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.0046259991        LPDIBLC2   = -2.0943082e-010
+WPDIBLC2   = -5.9638362e-010     PPDIBLC2   = 3.4445985e-017      PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0050713868
+LAIGC      = -5.8879979e-012     WAIGC      = 3.9584923e-011      PAIGC      = -4.1335182e-018
+BIGC       = 0.0010044568        WBIGC      = -6.3251531e-012     CIGC       = 1e-010
+AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011       BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.30625535         LKT1       = '-2.9080965e-009+dlkt1p_hvt'
+WKT1       = 3.5534568e-009      PKT1       = '-1.4753853e-029+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.90454863
+LUTE       = 2.2210976e-008      WUTE       = -8.2868793e-008     PUTE       = 2.5800043e-015
+UA1        = 3.0696338e-009      LUA1       = -1.4562802e-016     WUA1       = -5.898499e-016
+PUA1       = 7.2715474e-023      UB1        = -4.3292968e-018     LUB1       = 2.7647022e-025
+WUB1       = 7.9587763e-025      PUB1       = -1.0561139e-031     UC1        = -9.3440777e-011
+LUC1       = 1.9207798e-018      WUC1       = 7.2311382e-018      PUC1       = -1.0333795e-024
+PRT        = 0                   AT         = 505042.32           LAT        = '-0.019351408+dlatp_hvt'
+WAT        = -0.035783017        PAT        = '2.0667591e-009+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_hvt.20 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = '2.16e-007-dxw_hvt' WMAX       = '5.4e-007-dxw_hvt'  VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.606405E-09       LL         = 5.48932E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.48932E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.606405E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16491355+dvthp_hvt'
+LVTH0      = '6.9165112e-011+dlvthp_hvt'
+WVTH0      = '-4.0961304e-009+dwvthp_hvt'
+PVTH0      = '7.2391979e-017+dpvthp_hvt'
+K1         = 0.11                K2         = -0.065031213        LK2        = '6.0425157e-009+dlk2p_hvt'
+WK2        = -3.3661289e-009     PK2        = -7.2391979e-017     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '0.030160306+dvoffp_hvt'
+LVOFF      = '-1.0713047e-008+dlvoffp_hvt'
+WVOFF      = -1.5583053e-008     PVOFF      = '9.4109573e-016+dpvoffp_hvt'
+NFACTOR    = -3.8624379          LNFACTOR   = 4.1374193e-007      WNFACTOR   = 4.1224102e-007
+PNFACTOR   = '-3.6268381e-014+dpnfactorp_hvt'
+ETA0       = -0.66429013         LETA0      = '5.1663195e-008+dleta0p_hvt'
+WETA0      = '1.2659663e-007+dweta0p_hvt'
+PETA0      = -6.6962581e-015     ETAB       = 0.045173395         LETAB      = -3.3828028e-009
+WETAB      = -1.6087106e-008     PETAB      = 7.2391979e-016      U0         = '4.2995495+du0p_hvt'
+LU0        = 9.0913138e-007      WU0        = 1.4273036e-005      PU0        = '-2.0414538e-013+dpu0p_hvt'
+UA         = -5.4700515e-009     LUA        = 1.8449454e-016      WUA        = 1.4242867e-015
+PUA        = -6.6267618e-023     UB         = 8.0446647e-018      LUB        = -3.162063e-025
+WUB        = -1.9062513e-024     PUB        = 1.0786427e-031      UC         = 3.7348184e-010
+LUC        = -1.9642766e-017     WUC        = -1.4146087e-016     PUC        = 8.375752e-024
+VSAT       = 130098.32           LVSAT      = '0.0013455758+dlvsatp_hvt'
+WVSAT      = 0.016087106         PVSAT      = '-7.2391979e-010+dpvsatp_hvt'
+A0         = 9.1802373           LA0        = -8.67079e-008       WA0        = -8.5601485e-007
+PA0        = '9.0489974e-014+dpa0p_hvt'
+AGS        = 82.160945           LAGS       = -3.5902981e-006     WAGS       = -8.7735548e-006
+PAGS       = 5.0674385e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.50437692
+LKETA      = 1.8353906e-008      WKETA      = -1.5247018e-008     PKETA      = 1.0858797e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 0.98481586
+LPCLM      = -2.0372269e-008     WPCLM      = -7.1069136e-008     PPCLM      = '-4.6545866e-029+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = -0.0048568456       LPDIBLC2   = 3.3828028e-010
+WPDIBLC2   = 1.253365e-009       PPDIBLC2   = -7.2391979e-017     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0049694444
+WAIGC      = -3.1981111e-011     BIGC       = 0.0010044568        WBIGC      = -6.3251531e-012
+CIGC       = 1e-010              AIGSD      = 0.0042301852        WAIGSD     = 1.066037e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.25677729         LKT1       = '-5.7658553e-009+dlkt1p_hvt'
+WKT1       = -2.713368e-009      PKT1       = '3.6195989e-016+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.54352663
+LUTE       = 1.3590316e-009      WUTE       = -2.5540674e-008     PUTE       = -7.3115899e-016
+UA1        = 2.2392103e-010      LUA1       = 1.8734943e-017      WUA1       = 1.4888166e-015
+PUA1       = -4.7344354e-023     UB1        = 3.7701924e-018      LUB1       = -1.9134088e-025
+WUB1       = -2.8149195e-024     PUB1       = 1.0294139e-031      UC1        = -6.0185185e-011
+WUC1       = -1.066037e-017      PRT        = 0                   AT         = 146703.25
+LAT        = '0.0013455758+dlatp_hvt'
+WAT        = 0.01253365          PAT        = '-7.2391979e-010+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_hvt.21 PMOS	(	LEVEL      = 54                  LMIN       = '1.058003e-006-dxl_hvt'
+LMAX       = 1.21e-06            WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt'
+VERSION    = 4.4                 TEMPMOD    = 0                   RGEOMOD    = 1
+BINUNIT    = 2                   PARAMCHK   = 1                   MOBMOD     = 0
+CAPMOD     = 2                   IGCMOD     = 1                   IGBMOD     = 1
+GEOMOD     = 0                   DIOMOD     = 1                   RDSMOD     = 1
+RBODYMOD   = 0                   RGATEMOD   = 0                   PERMOD     = 1
+ACNQSMOD   = 0                   TRNQSMOD   = 0                   TNOM       = 25
+TOXE       = 'toxp_hvt'          TOXM       = 2.13e-009           DTOX       = 6.3e-010
+EPSROX     = 3.9                 WINT       = 6e-009              LINT       = 7.046563E-09
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17794444+dvthp_hvt'
+WVTH0      = '6.3011111e-010+dwvthp_hvt'
+K1         = 0.11                K2         = 0.028740741         WK2        = -2.9405185e-009
+K3         = -2.9                K3B        = -0.6                W0         = 5e-008
+DVT0       = 35                  DVT1       = 2.7                 DVT2       = 0.05
+DVT0W      = 4e-007              DVT1W      = 10000               DVT2W      = 0
+DSUB       = 1                   MINV       = 0                   VOFFL      = 0
+DVTP0      = 8e-007              DVTP1      = 3                   LPE0       = 1.9e-007
+LPEB       = 5e-008              XJ         = 1.2e-007            NGATE      = 7e+019
+NDEP       = 1.7200001e+017      NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = '-0.097925926+dvoffp_hvt'
+WVOFF      = 8.4014815e-010      NFACTOR    = 1.4903948           WNFACTOR   = 4.485551e-008
+ETA0       = 0.28037037          WETA0      = '4.2007407e-009+dweta0p_hvt'
+ETAB       = -0.03               U0         = '77.839364+du0p_hvt'
+LU0        = -9.3587104e-010     WU0        = 3.6210274e-006      PU0        = '9.9202331e-017+dpu0p_hvt'
+UA         = -1.003161e-009      LUA        = 9.3141452e-020      WUA        = 5.9717931e-017
+PUA        = -9.8729939e-027     UB         = 4.2015556e-018      WUB        = -2.9993289e-025
+UC         = 1.4907407e-010      WUC        = -1.0501852e-017     VSAT       = 160000
+A0         = 4.8976756           LA0        = -8.0217518e-011     WA0        = 3.8184638e-007
+PA0        = '8.5030569e-018+dpa0p_hvt'
+AGS        = 1.3787414           LAGS       = 1.7249265e-006      WAGS       = -8.5798906e-008
+PAGS       = -7.7944688e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.15947282
+LKETA      = -1.8717421e-007     WKETA      = 1.5844119e-008      PKETA      = 1.9840466e-014
+DWG        = 0                   DWB        = 0                   PCLM       = 0.4
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0054229481
+LAIGC      = -2.1345523e-010     WAIGC      = -1.0766026e-011     PAIGC      = 2.3619603e-018
+BIGC       = 0.00095162691       LBIGC      = 1.0709205e-013      WBIGC      = 4.9791168e-012
+PBIGC      = -1.1077594e-020     CIGC       = 1e-010              AIGSD      = 0.0041916667
+WAIGSD     = 1.8903333e-011      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.9000478
+LPIGCD     = -4.2732697e-010     NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.24518519         WKT1       = -2.1003704e-009     KT1L       = 0
+KT2        = -0.03875            UTE        = -1.4474797          LUTE       = -1.0561973e-009
+WUTE       = 8.4532846e-008      PUTE       = 1.1195692e-016      UA1        = 4.0330092e-009
+LUA1       = 1.3412069e-018      WUA1       = 1.5160695e-016      PUA1       = -1.7006114e-025
+UB1        = -4.3434151e-018     LUB1       = 7.6843884e-030      WUB1       = -2.3149699e-025
+PUB1       = 3.6137992e-035      UC1        = -1.1e-010           PRT        = 0
+AT         = 203649.22           LAT        = '0.1461908+dlatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthp_hvt'
+PVTH0      = '0+dpvthp_hvt'      LK2        = '0+dlk2p_hvt'       LVSAT      = '0+dlvsatp_hvt'
+PVSAT      = '0+dpvsatp_hvt'     PPCLM      = '0+dppclmp_hvt'     PNFACTOR   = '0+dpnfactorp_hvt'
+LVOFF      = '0+dlvoffp_hvt'     PVOFF      = '0+dpvoffp_hvt'     LETA0      = '0+dleta0p_hvt'
+LKT1       = '0+dlkt1p_hvt'      PKT1       = '0+dpkt1p_hvt'      PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.22 PMOS	(	LEVEL      = 54                  LMIN       = '4.340031e-007-dxl_hvt'
+LMAX       = '1.058003e-006-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.18151594+dvthp_hvt'
+LVTH0      = '3.5675916e-009+dlvthp_hvt'
+WVTH0      = '1.0086896e-009+dwvthp_hvt'
+PVTH0      = '-3.7816471e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.034693233         LK2        = '-5.945986e-009+dlk2p_hvt'
+WK2        = -3.5714827e-009     PK2        = 6.3027451e-016      K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.09959613+dvoffp_hvt'
+LVOFF      = '1.6683781e-009+dlvoffp_hvt'
+WVOFF      = 1.840441e-009       PVOFF      = '-9.9919939e-016+dpvoffp_hvt'
+NFACTOR    = 0.6800216           LNFACTOR   = 8.0948739e-007      WNFACTOR   = 2.2213259e-007
+PNFACTOR   = '-1.770833e-013+dpnfactorp_hvt'
+ETA0       = 0.28037037          WETA0      = '4.2007407e-009+dweta0p_hvt'
+ETAB       = -0.03               U0         = '63.320884+du0p_hvt'
+LU0        = 1.4501674e-005      WU0        = 7.9475272e-006      PU0        = '-4.3216713e-012+dpu0p_hvt'
+UA         = -1.7288085e-009     LUA        = 7.2494742e-016      WUA        = 2.3307107e-016
+PUA        = -1.7317352e-022     UB         = 6.1096354e-018      LUB        = -1.9059941e-024
+WUB        = -6.0090282e-025     PUB        = 3.0064094e-031      UC         = 2.1745097e-010
+LUC        = -6.8302152e-017     WUC        = -1.9991554e-017     PUC        = 9.4793286e-024
+VSAT       = 165896.86           LVSAT      = '-0.005890416+dlvsatp_hvt'
+WVSAT      = -0.0012619284       PVSAT      = '1.260549e-009+dpvsatp_hvt'
+A0         = 1.8387157           LA0        = 3.055536e-006       WA0        = 5.9018742e-007
+PA0        = '-2.0810479e-013+dpa0p_hvt'
+AGS        = 3.7381887           LAGS       = -6.3194161e-007     WAGS       = -3.4807044e-007
+PAGS       = 1.8404016e-013      A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.54278343
+LKETA      = 1.9571741e-007      WKETA      = 6.2206793e-008      PKETA      = -2.6471529e-014
+DWG        = 0                   DWB        = 0                   PCLM       = -0.013028443
+LPCLM      = 4.1257696e-007      WPCLM      = 1.1243782e-008      PPCLM      = '-1.1231492e-014+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = -0.0014143755       LPDIBLC2   = 2.4117364e-009
+WPDIBLC2   = -1.2619284e-010     PPDIBLC2   = 1.260549e-016       PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0052451967
+LAIGC      = -3.5898196e-011     WAIGC      = -9.6634099e-012     PAIGC      = 1.260549e-018
+BIGC       = 0.00095179134       LBIGC      = -5.7153706e-014     WBIGC      = 4.9621086e-012
+PBIGC      = 5.9119749e-021      CIGC       = 1e-010              AIGSD      = 0.0041916667
+WAIGSD     = 1.8903333e-011      BIGSD      = 7e-005              CIGSD      = 0.002267
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 2.8993917
+LPIGCD     = 2.2805912e-010      NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.20045804         LKT1       = '-4.467825e-008+dlkt1p_hvt'
+WKT1       = -5.8861557e-009     PKT1       = '3.7816471e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.06503554         LKT2       = 2.6256807e-008
+UTE        = -2.2910751          LUTE       = 8.4161708e-007      WUTE       = 2.0095687e-007
+PUTE       = -1.161848e-013      UA1        = 2.2076376e-009      LUA1       = 1.8247175e-015
+WUA1       = 6.1204058e-016      PUA1       = -4.6010039e-022     UB1        = -2.8104347e-018
+LUB1       = -1.531297e-024      WUB1       = -7.4594904e-025     PUB1       = 5.1392584e-031
+UC1        = -1.1e-010           PRT        = 0                   AT         = 350000
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LETA0      = '0+dleta0p_hvt'
+LAT        = '0+dlatp_hvt'       PAT        = '0+dpatp_hvt'       )

.MODEL pch_hvt.23 PMOS	(	LEVEL      = 54                  LMIN       = '2.020031e-007-dxl_hvt'
+LMAX       = '4.340031e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = 7.046563E-09        LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '7.046563E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.16772237+dvthp_hvt'
+LVTH0      = '-1.6037112e-009+dlvthp_hvt'
+WVTH0      = '-3.8813459e-010+dwvthp_hvt'
+PVTH0      = '1.4551434e-016+dpvthp_hvt'
+K1         = 0.11                K2         = 0.028597726         LK2        = '-3.660738e-009+dlk2p_hvt'
+WK2        = -2.9253589e-009     PK2        = 3.8803823e-016      K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.076728102+dvoffp_hvt'
+LVOFF      = '-6.9050034e-009+dlvoffp_hvt'
+WVOFF      = -1.0093363e-009     PVOFF      = '6.9201768e-017+dpvoffp_hvt'
+NFACTOR    = 3.5477513           LNFACTOR   = -2.6564427e-007     WNFACTOR   = -3.2670179e-007
+PNFACTOR   = '2.8678494e-014+dpnfactorp_hvt'
+ETA0       = 0.28037037          WETA0      = '4.2007407e-009+dweta0p_hvt'
+ETAB       = -0.03               U0         = '107.12458+du0p_hvt'
+LU0        = -1.920634e-006      WU0        = -3.5896125e-006     PU0        = '3.6819978e-015+dpu0p_hvt'
+UA         = 5.1884242e-010      LUA        = -1.1771242e-016     WUA        = -2.7787535e-016
+PUA        = 1.8383821e-023      UB         = 2.4422046e-019      LUB        = 2.929904e-025
+WUB        = 3.0946293e-025      PUB        = -4.0661459e-032     UC         = 2.9043007e-011
+LUC        = 2.3332928e-018      WUC        = 5.9657e-018         PUC        = -2.5222485e-025
+VSAT       = 144139.48           LVSAT      = '0.0022665785+dlvsatp_hvt'
+WVSAT      = 0.0033941523        PVSAT      = '-4.8504779e-010+dpvsatp_hvt'
+A0         = 11.789521           LA0        = -6.7508955e-007     WA0        = -1.1666082e-008
+PA0        = '1.7534235e-014+dpa0p_hvt'
+AGS        = -2.5896003          LAGS       = 1.7403901e-006      WAGS       = 3.0842928e-007
+PAGS       = -6.2086117e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = 0.061389662
+LKETA      = -3.0791255e-008     WKETA      = -2.0045519e-008     PKETA      = 4.3654301e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1.2645129
+LPCLM      = -6.6382096e-008     WPCLM      = -3.0241897e-008     PPCLM      = '4.3217758e-015+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.0071858486        LPDIBLC2   = -8.1254699e-010
+WPDIBLC2   = 3.3941523e-010      PPDIBLC2   = -4.8504779e-017     PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0051317636
+LAIGC      = 6.6286728e-012      WAIGC      = 2.7553627e-012      PAIGC      = -3.3953345e-018
+BIGC       = 0.00095163889       WBIGC      = 4.9778778e-012      CIGC       = 1e-010
+AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011      BIGSD      = 7e-005
+CIGSD      = 0.002267            NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'         XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_hvt'          CGDO       = 'cgop_hvt'
+CGBO       = 0                   CGDL       = 'cglp_hvt'          CGSL       = 'cglp_hvt'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_hvt'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.5
+MOIN       = 16.73               NOFF       = 1.827               VOFFCV     = -0.03
+KT1        = -0.30742414         LKT1       = '-4.5759225e-009+dlkt1p_hvt'
+WKT1       = 2.9069588e-009      PKT1       = '4.8504779e-016+dpkt1p_hvt'
+KT1L       = 0                   KT2        = 0.031949038         LKT2       = -1.010338e-008
+UTE        = 0.6170522           LUTE       = -2.4865991e-007     WUTE       = -1.8540873e-007
+PUTE       = 2.8666324e-014      UA1        = 1.0068412e-008      LUA1       = -1.1223412e-015
+WUA1       = -9.2260108e-016     PUA1       = 1.1524735e-022      UB1        = -9.3124842e-018
+LUB1       = 9.0636624e-025      WUB1       = 8.9888321e-025      PUB1       = -1.0273312e-031
+UC1        = -8.6159369e-011     LUC1       = -8.9380169e-018     WUC1       = -9.0564738e-018
+PUC1       = 3.3953345e-024      PRT        = 0                   AT         = 405323.95
+LAT        = '-0.020741331+dlatp_hvt'
+WAT        = -0.001293782        PAT        = '4.8504779e-010+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LETA0      = '0+dleta0p_hvt'     )

.MODEL pch_hvt.24 PMOS	(	LEVEL      = 54                  LMIN       = '1.079999e-007-dxl_hvt'
+LMAX       = '2.020031e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -1.20704E-09        LL         = 4.38278E-03
+WL         = 0                   LLN        = -0.84142            WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 4.38278E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-1.20704E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.17094279+dvthp_hvt'
+LVTH0      = '-1.1434923e-009+dlvthp_hvt'
+WVTH0      = '-9.3708352e-010+dwvthp_hvt'
+PVTH0      = '2.2396293e-016+dpvthp_hvt'
+K1         = 0.11                K2         = -0.013197697        LK2        = '2.3121163e-009+dlk2p_hvt'
+WK2        = 9.2974088e-010      PK2        = -1.6288213e-016     K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.096110941+dvoffp_hvt'
+LVOFF      = '-4.135062e-009+dlvoffp_hvt'
+WVOFF      = -3.160829e-009      PVOFF      = '3.7666492e-016+dpvoffp_hvt'
+NFACTOR    = 0.95088973          LNFACTOR   = 1.0546517e-007      WNFACTOR   = -1.4126675e-007
+PNFACTOR   = '2.1785485e-015+dpnfactorp_hvt'
+ETA0       = 0.2806216           LETA0      = '-3.5902426e-011+dleta0p_hvt'
+WETA0      = '7.0501855e-009+dweta0p_hvt'
+PETA0      = -4.0720532e-016     ETAB       = -0.03               U0         = '109.45501+du0p_hvt'
+LU0        = -2.2536679e-006     WU0        = -5.9499313e-006     PU0        = '3.4098783e-013+dpu0p_hvt'
+UA         = -4.1143387e-011     LUA        = -3.768658e-017      WUA        = -2.0866001e-016
+PUA        = 8.4924706e-024      UB         = 2.5372112e-018      LUB        = -3.46938e-026
+WUB        = -2.3836146e-026     PUB        = 6.9692783e-033      UC         = 5.8873955e-011
+LUC        = -1.9297554e-018     WUC        = 3.4883795e-018      PUC        = 1.0180133e-025
+VSAT       = 146559.22           LVSAT      = '0.0019207798+dlvsatp_hvt'
+WVSAT      = 0.0014247224        PVSAT      = '-2.0360266e-010+dpvsatp_hvt'
+A0         = 7.0597501           LA0        = 8.2732654e-010      WA0        = -3.8354374e-007
+PA0        = '7.0678118e-014+dpa0p_hvt'
+AGS        = 1.5435567           LAGS       = 1.1497335e-006      WAGS       = -1.0854663e-009
+PAGS       = -1.7854324e-014     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -0.050065069
+LKETA      = -1.4863605e-008     WKETA      = -2.3206497e-009     PKETA      = 1.8324239e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1.0858992
+LPCLM      = -4.0856961e-008     WPCLM      = 1.1397779e-008      PPCLM      = '-1.6288213e-015+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.0018391598        LPDIBLC2   = -4.8468276e-011
+PDIBLCB    = 0                   DROUT      = 0                   PVAG       = 0
+DELTA      = 0.020306            PSCBE1     = 9.264e+008          PSCBE2     = 1e-020
+FPROUT     = 0                   PDITS      = 0.1295569           PDITSD     = -2.203938
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '130+drdswp_hvt'    RDW        = '130+drdswp_hvt'    PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 0
+ALPHA1     = 0.7                 BETA0      = 14.31               AGIDL      = 7.379e-008
+BGIDL      = 2.3e+009            CGIDL      = 0.5                 EGIDL      = 0.53
+AIGBACC    = 0.01095             BIGBACC    = 0.00456             CIGBACC    = 0.2247
+NIGBACC    = 4.046               AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 1
+AIGC       = 0.0054144295        LAIGC      = -3.3766232e-011     WAIGC      = -3.3826205e-011
+PAIGC      = 1.8324239e-018      BIGC       = 0.00095163889       WBIGC      = 4.9778778e-012
+CIGC       = 1e-010              AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.35438004         LKT1       = '2.1343993e-009+dlkt1p_hvt'
+WKT1       = 1.385214e-008       PKT1       = '-1.0790941e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -1.5630737
+LUTE       = 6.2895127e-008      WUTE       = 5.8055575e-008      PUTE       = -6.126404e-015
+UA1        = 4.7260842e-010      LUA1       = 2.4896538e-016      WUA1       = -3.4086472e-017
+PUA1       = -1.1727513e-023     UB1        = -8.0225787e-019     LUB1       = -3.0980383e-025
+WUB1       = 4.1091308e-026      PUB1       = 1.9851259e-032      UC1        = -1.5498444e-010
+LUC1       = 8.9756066e-019      WUC1       = 2.0401482e-017      PUC1       = -8.1441064e-025
+PRT        = 0                   AT         = 314701.98           LAT        = '-0.0077908265+dlatp_hvt'
+WAT        = 0.0049498152        PAT        = '-4.0720532e-010+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_hvt.25 PMOS	(	LEVEL      = 54                  LMIN       = 9e-08
+LMAX       = '1.079999e-007-dxl_hvt'
+WMIN       = 1.08e-07            WMAX       = '2.16e-007-dxw_hvt' VERSION    = 4.4
+TEMPMOD    = 0                   RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 1                   IGBMOD     = 1                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_hvt'
+TOXM       = 2.13e-009           DTOX       = 6.3e-010            EPSROX     = 3.9
+WINT       = 6e-009              LINT       = -8.606405E-09       LL         = 5.48932E-03
+WL         = 0                   LLN        = -0.7901             WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 5.48932E-03         WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = '-8.606405E-09+ddlcp_hvt'
+DWC        = 0                   XL         = '-4.5E-08+dxl_hvt'  XW         = '0.01e-6+dxw_hvt'
+XPART      = 1                   TOXREF     = 3e-009              DLCIG      = 2.5e-009
+VTH0       = '-0.2656474+dvthp_hvt'
+LVTH0      = '4.3264664e-009+dlvthp_hvt'
+WVTH0      = '1.7460915e-008+dwvthp_hvt'
+PVTH0      = '-8.386705e-016+dpvthp_hvt'
+K1         = 0.11                K2         = -0.026923365        LK2        = '3.1048848e-009+dlk2p_hvt'
+WK2        = -1.1521208e-008     PK2        = 5.5626104e-016      K3         = -2.9
+K3B        = -0.6                W0         = 5e-008              DVT0       = 35
+DVT1       = 2.7                 DVT2       = 0.05                DVT0W      = 4e-007
+DVT1W      = 10000               DVT2W      = 0                   DSUB       = 1
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 8e-007
+DVTP1      = 3                   LPE0       = 1.9e-007            LPEB       = 5e-008
+XJ         = 1.2e-007            NGATE      = 7e+019              NDEP       = 1.7200001e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = '-0.03655173+dvoffp_hvt'
+LVOFF      = '-7.5750888e-009+dlvoffp_hvt'
+WVOFF      = -1.3066776e-009     PVOFF      = '2.6957266e-016+dpvoffp_hvt'
+NFACTOR    = -6.29534            LNFACTOR   = 5.2399363e-007      WNFACTOR   = 9.3288206e-007
+PNFACTOR   = '-5.9862246e-014+dpnfactorp_hvt'
+ETA0       = -0.072717097        LETA0      = '2.0372269e-008+dleta0p_hvt'
+ETAB       = -0.047309265        LETAB      = 9.9975026e-010      WETAB      = 3.7041827e-009
+PETAB      = -2.1394655e-016     U0         = '71.973511+du0p_hvt'
+LU0        = -8.8808004e-008     WU0        = -2.0919219e-007     PU0        = '9.4136484e-015+dpu0p_hvt'
+UA         = 4.424344e-009       LUA        = -2.9560465e-016     WUA        = -6.9311393e-016
+PUA        = 3.6473609e-023      UB         = -6.345587e-018      LUB        = 4.7835975e-025
+WUB        = 1.1732626e-024      PUB        = -6.2172869e-032     UC         = -6.606959e-010
+LUC        = 3.9631232e-017      WUC        = 7.9853166e-017      PUC        = -4.3088836e-024
+VSAT       = 249705.05           LVSAT      = '-0.0040367275+dlvsatp_hvt'
+WVSAT      = -0.0095087358       PVSAT      = '4.2789311e-010+dpvsatp_hvt'
+A0         = -16.228116          LA0        = 1.3458902e-006      WA0        = 4.5813727e-006
+PA0        = '-2.1608602e-013+dpa0p_hvt'
+AGS        = 16.568798           LAGS       = 2.8190407e-007      WAGS       = 5.2631647e-006
+PAGS       = -3.2190741e-013     A1         = 0                   A2         = 1
+B0         = 0                   B1         = 0                   KETA       = -1.0938359
+LKETA      = 4.5422615e-008      WKETA      = 1.108972e-007       PKETA      = -4.7068242e-015
+DWG        = 0                   DWB        = 0                   PCLM       = 1.0081839
+LPCLM      = -3.6368273e-008     WPCLM      = -7.6069886e-008     PPCLM      = '3.4231449e-015+dppclmp_hvt'
+PDIBLC1    = 0                   PDIBLC2    = 0.001               PDIBLCB    = 0
+DROUT      = 0                   PVAG       = 0                   DELTA      = 0.020306
+PSCBE1     = 9.264e+008          PSCBE2     = 1e-020              FPROUT     = 0
+PDITS      = 0.1295569           PDITSD     = -2.203938           PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '130+drdswp_hvt'
+RDW        = '130+drdswp_hvt'    PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 0                   ALPHA1     = 0.7
+BETA0      = 14.31               AGIDL      = 7.379e-008          BGIDL      = 2.3e+009
+CGIDL      = 0.5                 EGIDL      = 0.53                AIGBACC    = 0.01095
+BIGBACC    = 0.00456             CIGBACC    = 0.2247              NIGBACC    = 4.046
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 1                   AIGC       = 0.0048298148
+WAIGC      = -2.1003704e-012     BIGC       = 0.00095163889       WBIGC      = 4.9778778e-012
+CIGC       = 1e-010              AIGSD      = 0.0041916667        WAIGSD     = 1.8903333e-011
+BIGSD      = 7e-005              CIGSD      = 0.002267            NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 2.9                 NTOX       = 'ntoxp_hvt'
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_hvt'
+CGDO       = 'cgop_hvt'          CGBO       = 0                   CGDL       = 'cglp_hvt'
+CGSL       = 'cglp_hvt'          CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_hvt'           CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.5                 MOIN       = 16.73               NOFF       = 1.827
+VOFFCV     = -0.03               KT1        = -0.028785768        LKT1       = '-1.6671307e-008+dlkt1p_hvt'
+WKT1       = -5.1503554e-008     PKT1       = '2.6957266e-015+dpkt1p_hvt'
+KT1L       = 0                   KT2        = -0.03875            UTE        = -0.27649419
+LUTE       = -1.1415262e-008     WUTE       = -8.2685617e-008     PUTE       = 2.0025398e-015
+UA1        = 7.7940556e-009      LUA1       = -1.739075e-016      WUA1       = -1.3119219e-016
+PUA1       = -6.1188715e-024     UB1        = -1.4487781e-017     LUB1       = 4.8064597e-025
+WUB1       = 1.0922867e-024      PUB1       = -4.0863792e-032     UC1        = -2.4330003e-010
+LUC1       = 5.9985015e-018      WUC1       = 2.8526207e-017      PUC1       = -1.2836793e-024
+PRT        = 0                   AT         = 249705.05           LAT        = '-0.0040367275+dlatp_hvt'
+WAT        = -0.0095087358       PAT        = '4.2789311e-010+dpatp_hvt'
+JSS        = 1.4E-07             JSD        = 1.4E-07             JSWS       = 6.00E-13
+JSWD       = 6.00E-13            JSWGS      = 1.12E-12            JSWGD      = 1.12E-12
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_hvt'           CJD        = 'cjp_hvt'           MJS        = 0.35
+MJD        = 0.35                PBSWS      = 0.4                 PBSWD      = 0.4
+CJSWS      = 'cjswp_hvt'         CJSWD      = 'cjswp_hvt'         MJSWS      = 0.06
+MJSWD      = 0.06                PBSWGS     = 0.35                PBSWGD     = 0.35
+CJSWGS     = 'cjswgp_hvt'        CJSWGD     = 'cjswgp_hvt'        MJSWGS     = 0.9
+MJSWGD     = 0.9                 TPB        = 1.9E-03             TCJ        = 9.38E-04
+TPBSW      = 1.6E-03             TCJSW      = 6.0E-04             TPBSWG     = 5.0E-04
+TCJSWG     = 5.5E-03             XTIS       = 3                   XTID       = 3
+DMCG       = 9.65e-8             DMCI       = 9.65e-8             DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WETA0      = '0+dweta0p_hvt'     )

.ENDL MOS_hvt
*
*
*
*
*******************************************************************************************
*                                                                                         *
*                                  1.8V DEVICE MODEL                                      *
*                                                                                         *
*******************************************************************************************
*
.LIB MOS_18
**********************************************************************************************
*                                                                                            *
*                                   1.8V NMOS DEVICE MODELS                                    *
*                                                                                            *
**********************************************************************************************
.MODEL nch_18.1 NMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.33+dvthn_18'
+K1         = 0.2398              K2         = 0.06336             K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.1013703          NFACTOR    = 0.9246              ETA0       = 0.001
+ETAB       = -0.035              U0         = 653.0147            UA         = 1.573984e-010
+UB         = 3.030896e-018       UC         = 2.783e-010          VSAT       = '77000+dvsatn_18'
+A0         = 2.15                AGS        = 0.7445727           A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.068              DWG        = 0                   DWB        = 0
+PCLM       = 0.45                PDIBLC1    = 0                   PDIBLC2    = 0.0001
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.07
+UA1        = 3.6e-009            UB1        = -5.9e-018           UC1        = -1e-010
+PRT        = 0                   AT         = 160000              JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+LVTH0      = '0+dlvthn_18'       WVTH0      = '0+dwvthn_18'       PVTH0      = '0+dpvthn_18'
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+LU0        = '0+dlu0n_18'        )

.MODEL nch_18.2 NMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.33053211+dvthn_18'
+LVTH0      = '-4.7530829e-009+dlvthn_18'
+WVTH0      = '-4.7836793e-009+dwvthn_18'
+PVTH0      = '4.2730215e-014+dpvthn_18'
+K1         = 0.2398              K2         = 0.064831302         LK2        = -1.3142405e-008
+WK2        = -1.387267e-009      PK2        = 1.2391762e-014      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10487648         LVOFF      = 3.1318986e-008      WVOFF      = 1.2138586e-008
+PVOFF      = -1.0842792e-013     NFACTOR    = 0.88835269          LNFACTOR   = 3.2377907e-007
+WNFACTOR   = -2.0330637e-008     PNFACTOR   = 1.8160341e-013      ETA0       = 0.001
+ETAB       = -0.035              U0         = 673.96334           LU0        = '-0.00018712373+dlu0n_18'
+WU0        = -5.3997813e-005     PU0        = 4.8233546e-010      UA         = 2.6104653e-010
+LUA        = -9.2583696e-016     WUA        = 4.2253761e-017      PUA        = -3.7743172e-022
+UB         = 3.0498259e-018      LUB        = -1.6909145e-025     WUB        = -3.3664545e-025
+PUB        = 3.0070855e-030      UC         = 2.9692624e-010      LUC        = -1.6637886e-016
+WUC        = -9.8424201e-017     PUC        = 8.7917417e-022      VSAT       = '77000+dvsatn_18'
+A0         = 2.2206983           LA0        = -6.3151242e-007     WA0        = -9.6869505e-008
+PA0        = 8.6528686e-013      AGS        = 0.70165446          LAGS       = 3.8336716e-007
+WAGS       = 5.3816392e-008      PAGS       = -4.8071492e-013     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.066551311        LKETA      = -1.2940412e-008     DWG        = 0
+DWB        = 0                   PCLM       = 0.31763662          LPCLM      = 1.1823359e-006
+WPCLM      = 5.9795991e-007      PPCLM      = -5.3412769e-012     PDIBLC1    = 0
+PDIBLC2    = -0.00035309909      LPDIBLC2   = 4.0473076e-009      WPDIBLC2   = -1.1361238e-009
+PPDIBLC2   = 1.0148426e-014      PDIBLCB    = 0                   DROUT      = 0.56
+PVAG       = 0                   DELTA      = 0.015               PSCBE1     = 4e+008
+PSCBE2     = 1e-006              FPROUT     = 1000                PDITS      = 0.034
+PDITSD     = 0.4                 PDITSL     = 0                   RSH        = 11.58
+RDSW       = 200                 RSW        = 89                  RDW        = 89
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 1.684e-007          ALPHA1     = 5.889               BETA0      = 16.3
+AGIDL      = 1.488e-008          BGIDL      = 2.18e+009           CGIDL      = 0.636
+EGIDL      = 0.09287             AIGBACC    = 0.43                BIGBACC    = 0.054
+CIGBACC    = 0.075               NIGBACC    = 1                   AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 3                   AIGC       = 0.43                BIGC       = 0.054
+CIGC       = 0.075               AIGSD      = 0.43                BIGSD      = 0.054
+CIGSD      = 0.075               NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 1                   NTOX       = 1                   XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgon_18'           CGDO       = 'cgon_18'
+CGBO       = 0                   CGDL       = 'cgln_18'           CGSL       = 'cgln_18'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfn_18'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.07
+MOIN       = 15                  NOFF       = 1.29                VOFFCV     = -0.14
+KT1        = -0.3185             KT1L       = 0                   KT2        = -0.03076
+UTE        = -2.0989738          LUTE       = 2.5880824e-007      UA1        = 3.6395097e-009
+LUA1       = -3.5292032e-016     UB1        = -5.9262069e-018     LUB1       = 2.3409325e-025
+WUB1       = -1.1959198e-025     PUB1       = 1.0682554e-030      UC1        = -8.332691e-011
+LUC1       = -1.4893238e-016     PRT        = 0                   AT         = 167895.29
+LAT        = -0.070524717        WAT        = 0.0059795991        PAT        = -5.3412769e-008
+JSS        = 1.699E-07           JSD        = 1.699E-07           JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 8.5E-13             JSWGD      = 8.5E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.1                 IJTHSREV   = 0.01                IJTHDREV   = 0.1
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.6                 PBD        = 0.6
+CJS        = 'cjn_18'            CJD        = 'cjn_18'            MJS        = 0.3
+MJD        = 0.3                 PBSWS      = 0.65                PBSWD      = 0.65
+CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'          MJSWS      = 0.067
+MJSWD      = 0.067               PBSWGS     = 0.47                 PBSWGD     = 0.47
+CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38
+MJSWGD     = 0.38                TPB        = 1E-03               TCJ        = 1.14E-03
+TPBSW      = 2E-03               TCJSW      = 4E-04               TPBSWG     = 1.50E-03
+TCJSWG     = 2.01E-03            XTIS       = 3                   XTID       = 3
+JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32
+XTSSWGS    = 0.2464              XTSSWGD    = 0.2464              TNJTSSWG   = 0.8
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBSB       = 50                  )

.MODEL nch_18.3 NMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32066677+dvthn_18'
+LVTH0      = '5.5019389e-009+dlvthn_18'
+WVTH0      = '8.3905734e-008+dwvthn_18'
+PVTH0      = '-4.946243e-014+dpvthn_18'
+K1         = 0.2398              K2         = 0.057019963         LK2        = -5.0225184e-009
+WK2        = 2.4332663e-008      PK2        = -1.4344105e-014     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.02044493         LVOFF      = -5.6447614e-008     WVOFF      = -2.129108e-007
+PVOFF      = 1.2551092e-013      NFACTOR    = 1.2480738           LNFACTOR   = -5.015099e-008
+WNFACTOR   = 3.5659937e-007      PNFACTOR   = -2.1021533e-013     ETA0       = 0.001
+ETAB       = -0.035              U0         = 459.8789            LU0        = '3.5417042e-005+dlu0n_18'
+WU0        = 0.00094712164       PU0        = -5.583282e-010      UA         = -2.3647329e-010
+LUA        = -4.0866511e-016     WUA        = -7.4113096e-016     PUA        = 4.368967e-022
+UB         = 2.4095702e-018      LUB        = 4.964544e-025       WUB        = 5.9047612e-024
+PUB        = -3.4808567e-030     UC         = 5.20728e-011        LUC        = 8.8146284e-017
+WUC        = 1.7263605e-015      PUC        = -1.0176895e-021     VSAT       = '77000+dvsatn_18'
+A0         = 2.0745421           LA0        = -4.7958307e-007     WA0        = 1.6990911e-006
+PA0        = -1.0016142e-012     AGS        = 0.91384883          LAGS       = 1.6279111e-007
+WAGS       = -9.4393951e-007     PAGS       = 5.5645234e-013      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.079              DWG        = 0                   DWB        = 0
+PCLM       = 2.1166537           LPCLM      = -6.8774236e-007     WPCLM      = -1.0488217e-005
+PPCLM      = 6.1828038e-012      PDIBLC1    = 0                   PDIBLC2    = 0.002348858
+LPDIBLC2   = 1.2386232e-009      WPDIBLC2   = 1.9927612e-008      PPDIBLC2   = -1.1747327e-014
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.0858
+LUTE       = 2.451141e-007       UA1        = 3.65239e-009        LUA1       = -3.6630941e-016
+UB1        = -7.0778307e-018     LUB1       = 1.4312062e-024      WUB1       = 2.0976434e-024
+PUB1       = -1.2365608e-030     UC1        = -2.35246e-010       LUC1       = 8.987517e-018
+PRT        = 0                   AT         = 145966.54           LAT        = -0.047729774
+WAT        = -0.10488217         PAT        = 6.1828038e-008      JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.4 NMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.34301667+dvthn_18'
+LVTH0      = '-7.673325e-009+dlvthn_18'
+K1         = 0.2398              K2         = 0.062605333         LK2        = -8.315094e-009
+K3         = -0.6                K3B        = 2.7                 W0         = 1e-007
+DVT0       = 0.3                 DVT1       = 0.087               DVT2       = 0.05
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.3                 MINV       = 0                   VOFFL      = -5e-009
+DVTP0      = 6.901921e-007       DVTP1      = 5                   LPE0       = 6.6e-007
+LPEB       = 2.1e-007            XJ         = 1.4e-007            NGATE      = 3.046e+020
+NDEP       = 8e+017              NSD        = 1e+020              PHIN       = 0
+CDSC       = 1e-008              CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.070523333        LVOFF      = -2.6926395e-008
+NFACTOR    = 1.6363333           LNFACTOR   = -2.7903e-007        ETA0       = 0.001
+ETAB       = -0.035              U0         = 484.40983           LU0        = '2.095606e-005+dlu0n_18'
+UA         = -9.2440897e-010     LUA        = -3.1270195e-018     UB         = 3.0621395e-018
+LUB        = 1.1176477e-025      UC         = 2.2668667e-010      LUC        = -1.478859e-017
+VSAT       = '77000+dvsatn_18'   A0         = 2.0428283           LA0        = -4.608878e-007
+AGS        = 1.6515              LAGS       = -2.7205425e-007     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.08965            LKETA      = 6.278175e-009       DWG        = 0
+DWB        = 0                   PCLM       = 1.3523333           LPCLM      = -2.371755e-007
+PDIBLC1    = 0                   PDIBLC2    = 0.0049825           LPDIBLC2   = -3.1390875e-010
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -1.7528333
+LUTE       = 4.883025e-008       UA1        = 1.88435e-009        LUA1       = 6.7595018e-016
+UB1        = -3.0525e-018        LUB1       = -9.4172625e-025     UC1        = -3.0283333e-010
+LUC1       = 4.883025e-017       PRT        = 0                   AT         = 102275
+LAT        = -0.021973612        JSS        = 1.699E-07           JSD        = 1.699E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 8.5E-13
+JSWGD      = 8.5E-13             NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.1                 IJTHSREV   = 0.01
+IJTHDREV   = 0.1                 BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.6
+PBD        = 0.6                 CJS        = 'cjn_18'            CJD        = 'cjn_18'
+MJS        = 0.3                 MJD        = 0.3                 PBSWS      = 0.65
+PBSWD      = 0.65                CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'
+MJSWS      = 0.067               MJSWD      = 0.067               PBSWGS     = 0.47
+PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'
+MJSWGS     = 0.38                MJSWGD     = 0.38                TPB        = 1E-03
+TCJ        = 1.14E-03            TPBSW      = 2E-03               TCJSW      = 4E-04
+TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03            XTIS       = 3
+XTID       = 3                   JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008
+NJTSSWG    = 13.32               XTSSWGS    = 0.2464              XTSSWGD    = 0.2464
+TNJTSSWG   = 0.8                 VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthn_18'
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+PVTH0      = '0+dpvthn_18'       )

.MODEL nch_18.5 NMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32537701+dvthn_18'
+LVTH0      = '-2.0374532e-009+dlvthn_18'
+K1         = 0.2398              K2         = 0.017158476         LK2        = 6.2051769e-009
+K3         = -0.6                K3B        = 2.7                 W0         = 1e-007
+DVT0       = 0.3                 DVT1       = 0.087               DVT2       = 0.05
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.3                 MINV       = 0                   VOFFL      = -5e-009
+DVTP0      = 6.901921e-007       DVTP1      = 5                   LPE0       = 6.6e-007
+LPEB       = 2.1e-007            XJ         = 1.4e-007            NGATE      = 3.046e+020
+NDEP       = 8e+017              NSD        = 1e+020              PHIN       = 0
+CDSC       = 1e-008              CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.18229198         LVOFF      = 8.7836872e-009
+NFACTOR    = 0.69427005          LNFACTOR   = 2.1959218e-008      ETA0       = 0.001
+ETAB       = -0.035              U0         = 635.94063           LU0        = '-2.7458032e-005+dlu0n_18'
+UA         = -9.7924202e-010     LUA        = 1.4392139e-017      UB         = 3.9203811e-018
+LUB        = -1.6244343e-025     UC         = 1.7005508e-010      LUC        = 3.3052019e-018
+VSAT       = '77000+dvsatn_18'   A0         = -0.22849813         LA0        = 2.64801e-007
+AGS        = 0.88502674          LAGS       = -2.7166043e-008     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.10897059         LKETA      = 1.2451103e-008      DWG        = 0
+DWB        = 0                   PCLM       = 0.7942246           LPCLM      = -5.8859759e-008
+PDIBLC1    = 0                   PDIBLC2    = 0.0047085561        LPDIBLC2   = -2.2638369e-010
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.35392781
+LKT1       = 1.1319184e-008      KT1L       = 0                   KT2        = -0.03076
+UTE        = -2.0864238          LUTE       = 1.554124e-007       UA1        = 4.6334492e-009
+LUA1       = -2.0238702e-016     UB1        = -8.0796123e-018     LUB1       = 6.6443613e-025
+UC1        = -7.9144385e-011     LUC1       = -2.2638369e-017     PRT        = 0
+AT         = 44156.684           LAT        = -0.0034048107       JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+WVTH0      = '0+dwvthn_18'       PVTH0      = '0+dpvthn_18'       )

.MODEL nch_18.6 NMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32956049+dvthn_18'
+WVTH0      = '3.9511605e-009+dwvthn_18'
+K1         = 0.2398              K2         = 0.063399556         WK2        = -3.5560444e-010
+K3         = -0.6                K3B        = 2.7                 W0         = 1e-007
+DVT0       = 0.3                 DVT1       = 0.087               DVT2       = 0.05
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.3                 MINV       = 0                   VOFFL      = -5e-009
+DVTP0      = 6.901921e-007       DVTP1      = 5                   LPE0       = 6.6e-007
+LPEB       = 2.1e-007            XJ         = 1.4e-007            NGATE      = 3.046e+020
+NDEP       = 8e+017              NSD        = 1e+020              PHIN       = 0
+CDSC       = 1e-008              CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.10152086         WVOFF      = 1.3535688e-009
+NFACTOR    = 0.908976            WNFACTOR   = 1.404598e-007       ETA0       = 0.001
+ETAB       = -0.035              U0         = 647.09397           WU0        = 5.3227367e-005
+UA         = 9.1651298e-011      WUA        = 5.9106645e-016      UB         = 3.0422239e-018
+WUB        = -1.018382e-025      UC         = 2.8162926e-010      WUC        = -2.9930041e-017
+VSAT       = '77000+dvsatn_18'   A0         = 2.1335185           WA0        = 1.4816852e-007
+AGS        = 0.74694303          WAGS       = -2.13093e-008       A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.068879012        WKETA      = 7.902321e-009       DWG        = 0
+DWB        = 0                   PCLM       = 0.40055556          WPCLM      = 4.4450556e-007
+PDIBLC1    = 0                   PDIBLC2    = -0.00027358025      WPDIBLC2   = 3.3584864e-009
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.07
+UA1        = 3.6e-009            UB1        = -5.8351728e-018     WUB1       = -5.8279617e-025
+UC1        = -1e-010             PRT        = 0                   AT         = 160000
+JSS        = 1.699E-07           JSD        = 1.699E-07           JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 8.5E-13             JSWGD      = 8.5E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.1                 IJTHSREV   = 0.01                IJTHDREV   = 0.1
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.6                 PBD        = 0.6
+CJS        = 'cjn_18'            CJD        = 'cjn_18'            MJS        = 0.3
+MJD        = 0.3                 PBSWS      = 0.65                PBSWD      = 0.65
+CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'          MJSWS      = 0.067
+MJSWD      = 0.067               PBSWGS     = 0.47                 PBSWGD     = 0.47
+CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38
+MJSWGD     = 0.38                TPB        = 1E-03               TCJ        = 1.14E-03
+TPBSW      = 2E-03               TCJSW      = 4E-04               TPBSWG     = 1.50E-03
+TCJSWG     = 2.01E-03            XTIS       = 3                   XTID       = 3
+JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32
+XTSSWGS    = 0.2464              XTSSWGD    = 0.2464              TNJTSSWG   = 0.8
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+RBSB       = 50                  LVTH0      = '0+dlvthn_18'       PVTH0      = '0+dpvthn_18'
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+LU0        = '0+dlu0n_18'        )

.MODEL nch_18.7 NMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32944473+dvthn_18'
+LVTH0      = '1.0340711e-009+dlvthn_18'
+WVTH0      = '4.9918881e-009+dwvthn_18'
+PVTH0      = '-9.296299e-015+dpvthn_18'
+K1         = 0.2398              K2         = 0.064704969         LK2        = -1.1660604e-008
+WK2        = -2.5153169e-010     PK2        = -9.296299e-016      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10354977         LVOFF      = 1.8123184e-008      WVOFF      = 2.1140933e-010
+PVOFF      = 1.020234e-014       NFACTOR    = 0.86816355          LNFACTOR   = 3.6455717e-007
+WNFACTOR   = 1.6116976e-007      PNFACTOR   = -1.849917e-013      ETA0       = 0.001
+ETAB       = -0.035              U0         = 660.60305           LU0        = '-0.00012066988+dlu0n_18'
+WU0        = 6.6111184e-005      PU0        = -1.150847e-010      UA         = 1.9185196e-010
+LUA        = -8.9504243e-016     WUA        = 6.6431297e-016      PUA        = -6.5427457e-022
+UB         = 3.0211257e-018      LUB        = 1.8846034e-025      WUB        = -7.8630234e-026
+PUB        = -2.0730514e-031     UC         = 2.8855484e-010      LUC        = -6.1862721e-017
+WUC        = -2.3165312e-017     PUC        = -6.0425943e-023     VSAT       = '77000+dvsatn_18'
+A0         = 2.1900988           LA0        = -5.0540369e-007     WA0        = 1.7821953e-007
+PA0        = -2.6843063e-013     AGS        = 0.71097439          LAGS       = 3.2128987e-007
+WAGS       = -2.9969805e-008     PAGS       = 7.7359965e-014      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.067546089        LKETA      = -1.1906341e-008     WKETA      = 8.9430486e-009
+PKETA      = -9.296299e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.3354296           LPCLM      = 5.817376e-007       WPCLM      = 4.3800101e-007
+PPCLM      = 5.8101869e-014      PDIBLC1    = 0                   PDIBLC2    = -0.00091600296
+LPDIBLC2   = 5.7384409e-009      WPDIBLC2   = 3.924382e-009       PPDIBLC2   = -5.0548626e-015
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.0989738
+LUTE       = 2.5880824e-007      UA1        = 3.6395097e-009      LUA1       = -3.5292032e-016
+UB1        = -5.8675919e-018     LUB1       = 2.8958347e-025      WUB1       = -6.4654074e-025
+PUB1       = 5.6939831e-031      UC1        = -8.332691e-011      LUC1       = -1.4893238e-016
+PRT        = 0                   AT         = 168632.79           LAT        = -0.077112365
+WAT        = -0.00065045473      PAT        = 5.8101869e-009      JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.8 NMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.33101526+dvthn_18'
+LVTH0      = '-5.9849533e-010+dlvthn_18'
+WVTH0      = '-9.1271807e-009+dwvthn_18'
+PVTH0      = '5.380473e-015+dpvthn_18'
+K1         = 0.2398              K2         = 0.05884361          LK2        = -5.5677214e-009
+WK2        = 7.938079e-009       PK2        = -9.4427302e-015     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.045308019        LVOFF      = -4.2419113e-008     WVOFF      = 1.0608372e-008
+PVOFF      = -6.0530322e-016     NFACTOR    = 1.2973806           LNFACTOR   = -8.1613917e-008
+WNFACTOR   = -8.6668705e-008     PNFACTOR   = 7.2636386e-014      ETA0       = 0.001
+ETAB       = -0.035              U0         = 567.31304           LU0        = '-2.3694908e-005+dlu0n_18'
+WU0        = -1.8711244e-005     PU0        = -2.6911781e-011     UA         = -3.31842e-010
+LUA        = -3.5066256e-016     WUA        = 1.1623373e-016      PUA        = -8.4546198e-023
+UB         = 3.0798794e-018      LUB        = 1.2738582e-025      WUB        = -1.2131903e-025
+PUB        = -1.6293014e-031     UC         = 2.5117489e-010      LUC        = -2.3006261e-017
+WUC        = -6.3567258e-017     PUC        = -1.842812e-023      VSAT       = '77000+dvsatn_18'
+A0         = 2.3061216           LA0        = -6.2600931e-007     WA0        = -3.8280818e-007
+PA0        = 3.1475767e-013      AGS        = 0.79886772          LAGS       = 2.2992476e-007
+WAGS       = 8.9740733e-008      PAGS       = -4.7079139e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.07813637         LKETA      = -8.97743e-010       WKETA      = -7.7640304e-009
+PKETA      = 8.0707096e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.8156078           LPCLM      = 8.2592356e-008      WPCLM      = 1.2081859e-006
+PPCLM      = -7.4250528e-013     PDIBLC1    = 0                   PDIBLC2    = 0.0050009407
+LPDIBLC2   = -4.1222207e-010     WPDIBLC2   = -3.9146123e-009     PPDIBLC2   = 3.093772e-015
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.0829212
+LUTE       = 2.4212162e-007      WUTE       = -2.5880101e-008     PUTE       = 2.6902365e-014
+UA1        = 3.65239e-009        LUA1       = -3.663094e-016      UB1        = -6.8479062e-018
+LUB1       = 1.3086201e-024      WUB1       = 3.0621494e-026      PUB1       = -1.3451183e-031
+UC1        = -2.2804909e-010     LUC1       = 1.5063253e-018      WUC1       = -6.4700253e-017
+PUC1       = 6.7255913e-023      PRT        = 0                   AT         = 133750.62
+LAT        = -0.04085235         WAT        = 0.0049389506        JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.9 NMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.34249658+dvthn_18'
+LVTH0      = '-7.3667365e-009+dlvthn_18'
+WVTH0      = '4.6755399e-009+dwvthn_18'
+PVTH0      = '-2.7562308e-015+dpvthn_18'
+K1         = 0.24086617          LK1        = -6.2850646e-010     WK1        = -9.5848568e-009
+PK1        = 5.6502731e-015      K2         = 0.06386428          LK2        = -8.5274065e-009
+WK2        = -1.1317935e-008     PK2        = 1.9086898e-015      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.070080897        LVOFF      = -2.7815502e-008     WVOFF      = -3.9775016e-009
+PVOFF      = 7.9930693e-015      NFACTOR    = 1.6786852           LNFACTOR   = -3.0639303e-007
+WNFACTOR   = -3.807437e-007      PNFACTOR   = 2.459936e-013       ETA0       = 0.001
+ETAB       = -0.035              U0         = 497.31078           LU0        = '1.7571422e-005+dlu0n_18'
+WU0        = -0.00011597956      PU0        = 3.0427892e-011      UA         = -9.0464881e-010
+LUA        = -1.2992938e-017     WUA        = -1.7764381e-016     PUA        = 8.8694611e-023
+UB         = 3.1332735e-018      LUB        = 9.5910004e-026      WUB        = -6.3949457e-025
+PUB        = 1.4253434e-031      UC         = 2.4147349e-010      LUC        = -1.7287286e-017
+WUC        = -1.329335e-016      PUC        = 2.2463281e-023      VSAT       = '77000+dvsatn_18'
+A0         = 1.9410748           LA0        = -4.1081423e-007     WA0        = 9.1476445e-007
+PA0        = -4.5016139e-013     AGS        = 1.9351463           LAGS       = -4.3991146e-007
+WAGS       = -2.5499802e-006     PAGS       = 1.5090364e-012      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.089919198        LKETA      = 6.0482336e-009      WKETA      = 2.4200858e-009
+PKETA      = 2.0671731e-015      DWG        = 0                   DWB        = 0
+PCLM       = 1.3598542           LPCLM      = -2.382409e-007      WPCLM      = -6.7612588e-008
+PPCLM      = 9.577902e-015       PDIBLC1    = 0                   PDIBLC2    = 0.0047236492
+LPDIBLC2   = -2.4875869e-010     WPDIBLC2   = 2.3270689e-009      PPDIBLC2   = -5.8569904e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -1.7468813
+LUTE       = 4.4026085e-008      WUTE       = -5.3508739e-008     PUTE       = 4.3189447e-014
+UA1        = 1.9529053e-009      LUA1       = 6.3553683e-016      WUA1       = -6.1631214e-016
+PUA1       = 3.6331601e-022      UB1        = -3.090731e-018      LUB1       = -9.0623464e-025
+WUB1       = 3.436965e-025       PUB1       = -3.1906954e-031     UC1        = -3.1482819e-010
+LUC1       = 5.2662606e-017      WUC1       = 1.0783376e-016      PUC1       = -3.4452885e-023
+PRT        = 0                   AT         = 101400.57           LAT        = -0.021781995
+WAT        = 0.0078611631        PAT        = -1.7226442e-009     JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.10 NMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32702324+dvthn_18'
+LVTH0      = '-2.4230042e-009+dlvthn_18'
+WVTH0      = '-1.4799684e-008+dwvthn_18'
+PVTH0      = '3.4661034e-015+dpvthn_18'
+K1         = 0.23826061          LK1        = 2.0396891e-010      WK1        = 1.3839098e-008
+PK1        = -1.8336805e-015     K2         = 0.017417359         LK2        = 6.312385e-009
+WK2        = -2.327355e-009      PK2        = -9.6380036e-016     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.18815912         LVOFF      = 9.910491e-009       WVOFF      = 5.2745616e-008
+PVOFF      = -1.0129967e-014     NFACTOR    = 0.6195258           LNFACTOR   = 3.2008418e-008
+WNFACTOR   = 6.7195083e-007      PNFACTOR   = -9.0342307e-014     ETA0       = 0.001
+ETAB       = -0.035              U0         = 636.11686           LU0        = '-2.677712e-005+dlu0n_18'
+WU0        = -1.5842595e-006     PU0        = -6.1214069e-012     UA         = -1.005182e-009
+LUA        = 1.9127429e-017      WUA        = 2.3320085e-016      PUA        = -4.2570257e-023
+UB         = 3.9366414e-018      LUB        = -1.6076603e-025     WUB        = -1.4617962e-025
+PUB        = -1.5079786e-032     UC         = 1.7378254e-010      LUC        = 4.339971e-018
+WUC        = -3.3509856e-017     PUC        = -9.3025742e-024     VSAT       = '77000+dvsatn_18'
+A0         = -0.16104695         LA0        = 2.6081366e-007      WA0        = -6.0638613e-007
+PA0        = 3.5846218e-014      AGS        = 0.48914802          LAGS       = 2.2084987e-008
+WAGS       = 3.5589497e-006      PAGS       = -4.4276675e-013     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.11104943         LKETA      = 1.2799343e-008      WKETA      = 1.8688778e-008
+PKETA      = -3.130674e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.80137712          LPCLM      = -5.9807469e-008     WPCLM      = -6.4301175e-008
+PPCLM      = 8.5199057e-015      PDIBLC1    = 0                   PDIBLC2    = 0.004614691
+LPDIBLC2   = -2.1394656e-010     WPDIBLC2   = 8.4384745e-010      PPDIBLC2   = -1.1180979e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.35392781
+LKT1       = 1.1319184e-008      KT1L       = 0                   KT2        = -0.03076
+UTE        = -2.1086795          LUTE       = 1.5962061e-007      WUTE       = 2.0007869e-007
+PUTE       = -3.7831736e-014     UA1        = 4.5099892e-009      LUA1       = -1.8145148e-016
+WUA1       = 1.1099055e-015      PUA1       = -1.8821053e-022     UB1        = -7.9616654e-018
+LUB1       = 6.5002891e-025      WUB1       = -1.0603425e-024     PUB1       = 1.295209e-031
+UC1        = -7.9144385e-011     LUC1       = -2.2638369e-017     PRT        = 0
+AT         = 43807.254           LAT        = -0.0033809314       WAT        = 0.0031413839
+PAT        = -2.1467479e-010     JSS        = 1.699E-07           JSD        = 1.699E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 8.5E-13
+JSWGD      = 8.5E-13             NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.1                 IJTHSREV   = 0.01
+IJTHDREV   = 0.1                 BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.6
+PBD        = 0.6                 CJS        = 'cjn_18'            CJD        = 'cjn_18'
+MJS        = 0.3                 MJD        = 0.3                 PBSWS      = 0.65
+PBSWD      = 0.65                CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'
+MJSWS      = 0.067               MJSWD      = 0.067               PBSWGS     = 0.47
+PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'
+MJSWGS     = 0.38                MJSWGD     = 0.38                TPB        = 1E-03
+TCJ        = 1.14E-03            TPBSW      = 2E-03               TCJSW      = 4E-04
+TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03            XTIS       = 3
+XTID       = 3                   JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008
+NJTSSWG    = 13.32               XTSSWGS    = 0.2464              XTSSWGD    = 0.2464
+TNJTSSWG   = 0.8                 VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.11 NMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32663889+dvthn_18'
+WVTH0      = '6.5513889e-009+dwvthn_18'
+K1         = 0.2398              K2         = 0.070361111         WK2        = -6.5513889e-009
+K3         = -0.6                K3B        = 2.7                 W0         = 1e-007
+DVT0       = 0.3                 DVT1       = 0.087               DVT2       = 0.05
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.3                 MINV       = 0                   VOFFL      = -5e-009
+DVTP0      = 6.901921e-007       DVTP1      = 5                   LPE0       = 6.6e-007
+LPEB       = 2.1e-007            XJ         = 1.4e-007            NGATE      = 3.046e+020
+NDEP       = 8e+017              NSD        = 1e+020              PHIN       = 0
+CDSC       = 1e-008              CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.097055556        WVOFF      = -2.6205556e-009
+NFACTOR    = 1.459579            WNFACTOR   = -3.4957687e-007     ETA0       = -0.0048888889
+WETA0      = 5.2411111e-009      ETAB       = -0.042361111        WETAB      = 6.5513889e-009
+U0         = 529.01581           WU0        = 0.00015831693       UA         = -2.3684416e-010
+WUA        = 8.8342741e-016      UB         = 2.8656698e-018      WUB        = 5.5295032e-026
+UC         = 2.5241667e-010      WUC        = -3.9308333e-018     VSAT       = '77000+dvsatn_18'
+A0         = 2.4472222           WA0        = -1.3102778e-007     AGS        = 0.67853889
+WAGS       = 3.9570389e-008      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.06
+DWG        = 0                   DWB        = 0                   PCLM       = 0.9
+PDIBLC1    = 0                   PDIBLC2    = 0.0024694444        WPDIBLC2   = 9.1719444e-010
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.1141667
+WUTE       = 3.9308333e-008      UA1        = 3.6e-009            UB1        = -6.5768611e-018
+WUB1       = 7.7306389e-026      UC1        = -1e-010             PRT        = 0
+AT         = 160000              JSS        = 1.699E-07           JSD        = 1.699E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 8.5E-13
+JSWGD      = 8.5E-13             NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.1                 IJTHSREV   = 0.01
+IJTHDREV   = 0.1                 BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.6
+PBD        = 0.6                 CJS        = 'cjn_18'            CJD        = 'cjn_18'
+MJS        = 0.3                 MJD        = 0.3                 PBSWS      = 0.65
+PBSWD      = 0.65                CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'
+MJSWS      = 0.067               MJSWD      = 0.067               PBSWGS     = 0.47
+PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'
+MJSWGS     = 0.38                MJSWGD     = 0.38                TPB        = 1E-03
+TCJ        = 1.14E-03            TPBSW      = 2E-03               TCJSW      = 4E-04
+TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03            XTIS       = 3
+XTID       = 3                   JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008
+NJTSSWG    = 13.32               XTSSWGS    = 0.2464              XTSSWGD    = 0.2464
+TNJTSSWG   = 0.8                 VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  LVTH0      = '0+dlvthn_18'
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+PVTH0      = '0+dpvthn_18'       LU0        = '0+dlu0n_18'        )

.MODEL nch_18.12 NMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.32720776+dvthn_18'
+LVTH0      = '-5.0813991e-009+dlvthn_18'
+WVTH0      = '6.9827945e-009+dwvthn_18'
+PVTH0      = '-3.8535305e-015+dpvthn_18'
+K1         = 0.2398              K2         = 0.071841627         LK2        = -1.3224709e-008
+WK2        = -6.6031576e-009     PK2        = 4.6242366e-016      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10078465         LVOFF      = 3.3310123e-008      WVOFF      = -2.2495467e-009
+PVOFF      = -3.3140362e-015     NFACTOR    = 1.4937653           LNFACTOR   = -3.0536902e-007
+WNFACTOR   = -3.9561579e-007     PNFACTOR   = 4.1124261e-013      ETA0       = -0.0048888889
+WETA0      = 5.2411111e-009      ETAB       = -0.042361111        WETAB      = 6.5513889e-009
+U0         = 544.15922           LU0        = '-0.00013526853+dlu0n_18'
+WU0        = 0.0001697462        PU0        = -1.0209189e-010     UA         = -1.5457303e-010
+LUA        = -7.3488689e-016     WUA        = 9.7263121e-016      PUA        = -7.96813e-022
+UB         = 2.9088052e-018      LUB        = -3.8530766e-025     WUB        = 2.1334956e-026
+PUB        = 3.0334838e-031      UC         = 2.6552767e-010      LUC        = -1.17114e-016
+WUC        = -2.671129e-018      PUC        = -1.1252309e-023     VSAT       = '77000+dvsatn_18'
+A0         = 2.5503645           LA0        = -9.2131812e-007     WA0        = -1.4241689e-007
+PA0        = 1.0173321e-013      AGS        = 0.64443398          LAGS       = 3.0464213e-007
+WAGS       = 2.9251167e-008      PAGS       = 9.2176449e-014      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.059048841        LKETA      = -8.49623e-009       WKETA      = 1.3804979e-009
+PKETA      = -1.2331298e-014     DWG        = 0                   DWB        = 0
+PCLM       = 0.76842907          LPCLM      = 1.1752574e-006      WPCLM      = 5.2631483e-008
+PPCLM      = -4.7013072e-013     PDIBLC1    = 0                   PDIBLC2    = 0.0025055153
+LPDIBLC2   = -3.2220319e-010     WPDIBLC2   = 8.7923075e-010      PPDIBLC2   = 3.3911068e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.32158285
+LKT1       = 2.7537589e-008      WKT1       = 2.7437396e-009      PKT1       = -2.4508454e-014
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.1559372
+LUTE       = 3.7311521e-007      WUTE       = 5.0697441e-008      PUTE       = -1.0173321e-013
+UA1        = 3.3413066e-009      LUA1       = 2.3107785e-015      WUA1       = 2.6540072e-016
+PUA1       = -2.370692e-021      UB1        = -6.2968069e-018     LUB1       = -2.5015842e-024
+WUB1       = -2.6453941e-025     PUB1       = 3.0535376e-030      UC1        = -8.332691e-011
+LUC1       = -1.4893238e-016     PRT        = 0                   AT         = 167901.94
+LAT        = -0.070584065        JSS        = 1.699E-07           JSD        = 1.699E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 8.5E-13
+JSWGD      = 8.5E-13             NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.1                 IJTHSREV   = 0.01
+IJTHDREV   = 0.1                 BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.6
+PBD        = 0.6                 CJS        = 'cjn_18'            CJD        = 'cjn_18'
+MJS        = 0.3                 MJD        = 0.3                 PBSWS      = 0.65
+PBSWD      = 0.65                CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'
+MJSWS      = 0.067               MJSWD      = 0.067               PBSWGS     = 0.47
+PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'
+MJSWGS     = 0.38                MJSWGD     = 0.38                TPB        = 1E-03
+TCJ        = 1.14E-03            TPBSW      = 2E-03               TCJSW      = 4E-04
+TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03            XTIS       = 3
+XTID       = 3                   JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008
+NJTSSWG    = 13.32               XTSSWGS    = 0.2464              XTSSWGD    = 0.2464
+TNJTSSWG   = 0.8                 VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.13 NMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.31225792+dvthn_18'
+LVTH0      = '1.0458958e-008+dlvthn_18'
+WVTH0      = '7.5668542e-009+dwvthn_18'
+PVTH0      = '-4.4606605e-015+dpvthn_18'
+K1         = 0.2398              K2         = 0.090574            LK2        = -3.2697011e-008
+WK2        = -2.0301968e-008     PK2        = 1.4702337e-014      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.027953792        LVOFF      = -4.2397552e-008     WVOFF      = -4.8368904e-009
+PVOFF      = -6.2449247e-016     NFACTOR    = 1.2                 ETA0       = -0.0048888889
+WETA0      = 5.2411111e-009      ETAB       = -0.042361111        WETAB      = 6.5513889e-009
+U0         = 357.15155           LU0        = '5.9125935e-005+dlu0n_18'
+WU0        = 0.00016833248       PU0        = -1.0062233e-010     UA         = -7.6398635e-010
+LUA        = -1.0140175e-016     WUA        = 5.008422e-016       PUA        = -3.0638832e-022
+UB         = 2.2914644e-018      LUB        = 2.5641813e-025      WUB        = 5.8037034e-025
+PUB        = -2.777689e-031      UC         = 2.0147217e-010      LUC        = -5.0528305e-017
+WUC        = -1.9331838e-017     PUC        = 6.0664983e-024      VSAT       = '77000+dvsatn_18'
+A0         = 1.9646278           LA0        = -3.1244482e-007     WA0        = -7.8878722e-008
+PA0        = 3.5685284e-014      AGS        = 0.90220278          LAGS       = 3.6691462e-008
+WAGS       = -2.2274722e-009     PAGS       = 1.2489849e-013      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.073153611        LKETA      = 6.1656788e-009      WKETA      = -1.2198686e-008
+PKETA      = 1.7842642e-015      DWG        = 0                   DWB        = 0
+PCLM       = 3.2817328           LPCLM      = -1.4373218e-006     WPCLM      = -9.8666537e-007
+PPCLM      = 6.1021836e-013      PDIBLC1    = 0                   PDIBLC2    = -0.0012726694
+LPDIBLC2   = 3.6052199e-009      WPDIBLC2   = 1.6689008e-009      PPDIBLC2   = -4.8175134e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.26442675
+LKT1       = -3.1876181e-008     WKT1       = -4.8125192e-008     PKT1       = 2.8369801e-014
+KT1L       = 0                   KT2        = -0.03076            UTE        = -1.3454139
+LUTE       = -4.6942376e-007     WUTE       = -6.8226164e-007     PUTE       = 6.6017776e-013
+UA1        = 8.9677306e-009      LUA1       = -3.5378892e-015     WUA1       = -4.7306531e-015
+PUA1       = 2.822706e-021       UB1        = -1.0954714e-017     LUB1       = 2.3403101e-024
+WUB1       = 3.6856804e-024      PUB1       = -1.0527159e-030     UC1        = -3.00746e-010
+LUC1       = 7.7074767e-017      PRT        = 0                   AT         = 121460.35
+LAT        = -0.022308031        WAT        = 0.015877291         PAT        = -1.6504444e-008
+JSS        = 1.699E-07           JSD        = 1.699E-07           JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 8.5E-13             JSWGD      = 8.5E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.1                 IJTHSREV   = 0.01                IJTHDREV   = 0.1
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.6                 PBD        = 0.6
+CJS        = 'cjn_18'            CJD        = 'cjn_18'            MJS        = 0.3
+MJD        = 0.3                 PBSWS      = 0.65                PBSWD      = 0.65
+CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'          MJSWS      = 0.067
+MJSWD      = 0.067               PBSWGS     = 0.47                 PBSWGD     = 0.47
+CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38
+MJSWGD     = 0.38                TPB        = 1E-03               TCJ        = 1.14E-03
+TPBSW      = 2E-03               TCJSW      = 4E-04               TPBSWG     = 1.50E-03
+TCJSWG     = 2.01E-03            XTIS       = 3                   XTID       = 3
+JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32
+XTSSWGS    = 0.2464              XTSSWGD    = 0.2464              TNJTSSWG   = 0.8
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBSB       = 50                  )

.MODEL nch_18.14 NMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.34775+dvthn_18'
+LVTH0      = '-1.0463625e-008+dlvthn_18'
+K1         = 0.20744898          LK1        = 1.9070925e-008      WK1        = 2.015644e-008
+PK1        = -1.1882221e-014     K2         = 0.056893829         LK2        = -1.284255e-008
+WK2        = -5.1142325e-009     PK2        = 5.7491671e-015      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.051026343        LVOFF      = -2.8796284e-008     WVOFF      = -2.0936055e-008
+PVOFF      = 8.8659651e-015      NFACTOR    = 1.2909523           LNFACTOR   = -5.361639e-008
+WNFACTOR   = -3.5661394e-008     PNFACTOR   = 2.1022391e-014      ETA0       = -0.0048888889
+WETA0      = 5.2411111e-009      ETAB       = -0.042361111        WETAB      = 6.5513889e-009
+U0         = 222.95935           LU0        = '0.00013823224+dlu0n_18'
+WU0        = 0.00012819321       PU0        = -7.6960233e-011     UA         = -9.2360845e-010
+LUA        = -7.304519e-018      WUA        = -1.6076974e-016     PUA        = 8.3631918e-023
+UB         = 9.1664852e-019      LUB        = 1.0668721e-024      WUB        = 1.3333017e-024
+PUB        = -7.2162192e-031     UC         = 2.4133819e-011      LUC        = 5.4012651e-017
+WUC        = 6.0498801e-017      PUC        = -4.0993663e-023     VSAT       = '77000+dvsatn_18'
+A0         = 3.3618042           LA0        = -1.1360803e-006     WA0        = -3.4968475e-007
+PA0        = 1.9532544e-013      AGS        = -2.0191991          LAGS       = 1.7588579e-006
+WAGS       = 9.6938718e-007      PAGS       = -4.4786834e-013     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.064699537        LKETA      = 1.1820021e-009      WKETA      = -2.0025412e-008
+PKETA      = 6.3981191e-015      DWG        = 0                   DWB        = 0
+PCLM       = 1.4409073           LPCLM      = -3.5215524e-007     WPCLM      = -1.3974986e-007
+PPCLM      = 1.1096167e-013      PDIBLC1    = 0                   PDIBLC2    = 0.0035260384
+LPDIBLC2   = 7.763816e-010       WPDIBLC2   = 3.3929425e-009      PPDIBLC2   = -1.4980739e-015
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -1.923086
+LUTE       = -1.2888607e-007     WUTE       = 1.0331342e-007      PUTE       = 1.9708126e-013
+UA1        = 2.8578864e-010      LUA1       = 1.5801156e-015      WUA1       = 8.6742169e-016
+PUA1       = -4.773591e-022      UB1        = -2.6214557e-018     LUB1       = -2.5721456e-024
+WUB1       = -7.3958454e-026     PUB1       = 1.1635912e-030      UC1        = -1.9366667e-010
+LUC1       = 1.39515e-017        PRT        = 0                   AT         = 138223.96
+LAT        = -0.03219018         WAT        = -0.024911656        PAT        = 7.5406404e-009
+JSS        = 1.699E-07           JSD        = 1.699E-07           JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 8.5E-13             JSWGD      = 8.5E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.1                 IJTHSREV   = 0.01                IJTHDREV   = 0.1
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.6                 PBD        = 0.6
+CJS        = 'cjn_18'            CJD        = 'cjn_18'            MJS        = 0.3
+MJD        = 0.3                 PBSWS      = 0.65                PBSWD      = 0.65
+CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'          MJSWS      = 0.067
+MJSWD      = 0.067               PBSWGS     = 0.47                 PBSWGD     = 0.47
+CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38
+MJSWGD     = 0.38                TPB        = 1E-03               TCJ        = 1.14E-03
+TPBSW      = 2E-03               TCJSW      = 4E-04               TPBSWG     = 1.50E-03
+TCJSWG     = 2.01E-03            XTIS       = 3                   XTID       = 3
+JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32
+XTSSWGS    = 0.2464              XTSSWGD    = 0.2464              TNJTSSWG   = 0.8
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBSB       = 50                  WVTH0      = '0+dwvthn_18'       PVTH0      = '0+dpvthn_18'       )

.MODEL nch_18.15 NMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.3036139+dvthn_18'
+LVTH0      = '3.6378601e-009+dlvthn_18'
+WVTH0      = '6.034635e-009+dwvthn_18'
+PVTH0      = '-1.9280659e-015+dpvthn_18'
+K1         = 0.28651003          LK1        = -6.1890785e-009     WK1        = -2.9102881e-008
+PK1        = 3.8561317e-015      K2         = -0.0060745455       LK2        = 7.275846e-009
+WK2        = 1.858044e-008       PK2        = -1.8212807e-015     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.14458221         LVOFF      = 1.0948167e-009      WVOFF      = 1.3962166e-008
+PVOFF      = -2.2840165e-015     NFACTOR    = 1.2645155           LNFACTOR   = -4.5169835e-008
+WNFACTOR   = 9.7909981e-008      PNFACTOR   = -2.1653663e-014     ETA0       = -0.0048888889
+WETA0      = 5.2411111e-009      ETAB       = -0.042361111        WETAB      = 6.5513889e-009
+U0         = 829.44544           LU0        = '-5.5540069e-005+dlu0n_18'
+WU0        = -0.0001736467       PU0        = 1.9477618e-011      UA         = -8.8195663e-010
+LUA        = -2.0612276e-017     WUA        = 1.2353022e-016      PUA        = -7.2019193e-024
+UB         = 5.4556705e-018      LUB        = -3.8334542e-025     WUB        = -1.4981155e-024
+PUB        = 1.8301587e-031      UC         = 2.8883372e-010      LUC        = -3.0558968e-017
+WUC        = -1.3590541e-016     PUC        = 2.1757482e-023      VSAT       = '77000+dvsatn_18'
+A0         = 0.075030088         LA0        = -8.5956001e-008     WA0        = -8.1649469e-007
+PA0        = 3.4447121e-013      AGS        = 6.4133512           LAGS       = -9.3534195e-007
+WAGS       = -1.7135911e-006     PAGS       = 4.0934321e-013      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.095266563        LKETA      = 1.0948167e-008      WKETA      = 4.6420269e-009
+PKETA      = -1.4831276e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.37137625          LPCLM      = -1.0440061e-008     WPCLM      = 3.183996e-007
+PPCLM      = -3.5417087e-014     PDIBLC1    = 0                   PDIBLC2    = 0.0085199579
+LPDIBLC2   = -8.1917567e-010     WPDIBLC2   = -2.6318401e-009     PPDIBLC2   = 4.2684412e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.32638859
+LKT1       = 2.5204051e-009      WKT1       = -2.4509902e-008     PKT1       = 7.8309137e-015
+KT1L       = 0                   KT2        = -0.03076            UTE        = -3.1502717
+LUTE       = 2.6319977e-007      WUTE       = 1.1270958e-006      PUTE       = -1.3001719e-013
+UA1        = 6.7518659e-009      LUA1       = -4.857961e-016      WUA1       = -8.853648e-016
+PUA1       = 8.2656184e-023      UB1        = -1.5215133e-017     LUB1       = 1.4515344e-024
+WUB1       = 5.3952438e-024      PUB1       = -5.8381894e-031     UC1        = -2.698678e-011
+LUC1       = -3.9302724e-017     WUC1       = -4.6420269e-017     PUC1       = 1.4831276e-023
+PRT        = 0                   AT         = 40057.074           LAT        = -0.00082586028
+WAT        = 0.0064790433        PAT        = -2.4886881e-009     JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.16 NMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = 3.96e-007       WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.35427917+dvthn_18'
+WVTH0      = '-8.0979583e-009+dwvthn_18'
+K1         = 0.2398              K2         = 0.056659722         WK2        = 7.1034722e-010
+K3         = -0.6                K3B        = 2.7                 W0         = 1e-007
+DVT0       = 0.3                 DVT1       = 0.087               DVT2       = 0.05
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.3                 MINV       = 0                   VOFFL      = -5e-009
+DVTP0      = 6.901921e-007       DVTP1      = 5                   LPE0       = 6.6e-007
+LPEB       = 2.1e-007            XJ         = 1.4e-007            NGATE      = 3.046e+020
+NDEP       = 8e+017              NSD        = 1e+020              PHIN       = 0
+CDSC       = 1e-008              CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12880556         WVOFF      = 1.4206944e-008
+NFACTOR    = 0.88041667          WNFACTOR   = -4.2620833e-008     ETA0       = 0.010361111
+WETA0      = -2.8413889e-009     ETAB       = -0.03               U0         = 540.17576
+WU0        = 0.00015240216       UA         = -1.0579214e-010     WUA        = 8.1396983e-016
+UB         = 2.9240553e-018      WUB        = 2.4350703e-026      UC         = 2.9325e-010
+WUC        = -2.55725e-017       VSAT       = '77000+dvsatn_18'   A0         = 1.6102778
+WA0        = 3.1255278e-007      AGS        = 0.73497222          WAGS       = 9.6607222e-009
+A1         = 0                   A2         = 0.99                B0         = 0
+B1         = 0                   KETA       = -0.06               DWG        = 0
+DWB        = 0                   PCLM       = 0.9                 PDIBLC1    = 0
+PDIBLC2    = 0.00079569444       WPDIBLC2   = 1.8042819e-009      PDIBLCB    = 0
+DROUT      = 0.56                PVAG       = 0                   DELTA      = 0.015
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 1000
+PDITS      = 0.034               PDITSD     = 0.4                 PDITSL     = 0
+RSH        = 11.58               RDSW       = 200                 RSW        = 89
+RDW        = 89                  PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 1.684e-007          ALPHA1     = 5.889
+BETA0      = 16.3                AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgon_18'
+CGDO       = 'cgon_18'           CGBO       = 0                   CGDL       = 'cgln_18'
+CGSL       = 'cgln_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfn_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.07                MOIN       = 15                  NOFF       = 1.29
+VOFFCV     = -0.14               KT1        = -0.3185             KT1L       = 0
+KT2        = -0.03076            UTE        = -2.04               UA1        = 3.6e-009
+UB1        = -6.2460417e-018     WUB1       = -9.8027917e-026     UC1        = -1e-010
+PRT        = 0                   AT         = 160000              JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+LVTH0      = '0+dlvthn_18'       PVTH0      = '0+dpvthn_18'       LU0        = '0+dlu0n_18'        )

.MODEL nch_18.17 NMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = 3.96e-007       WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.3582038+dvthn_18'
+LVTH0      = '-3.5056752e-008+dlvthn_18'
+WVTH0      = '-9.4451071e-009+dwvthn_18'
+PVTH0      = '1.2033407e-014+dpvthn_18'
+K1         = 0.2398              K2         = 0.058148469         LK2        = -1.3298234e-008
+WK2        = 6.5421602e-010      PK2        = 5.0139195e-016      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.13642398         LVOFF      = 6.8051535e-008      WVOFF      = 1.6639296e-008
+PVOFF      = -2.1726984e-014     NFACTOR    = 0.83832787          LNFACTOR   = 3.7595818e-007
+WNFACTOR   = -4.8233953e-008     PNFACTOR   = 5.0139195e-014      ETA0       = 0.010361111
+WETA0      = -2.8413889e-009     ETAB       = -0.03               U0         = 559.84218
+LU0        = '-0.00017567026+dlu0n_18'
+WU0        = 0.00016143423       PU0        = -8.0678978e-011     UA         = 4.076272e-011
+LUA        = -1.3091013e-015     WUA        = 8.6910326e-016      PUA        = -4.9247937e-022
+UB         = 2.9221291e-018      LUB        = 1.7205193e-026      WUB        = 1.4273281e-026
+PUB        = 9.0016567e-032      UC         = 3.1459804e-010      LUC        = -1.9069135e-016
+WUC        = -2.8678426e-017     PUC        = 2.7743688e-023      VSAT       = '77000+dvsatn_18'
+A0         = 1.5860232           LA0        = 2.1665387e-007      WA0        = 3.6868398e-007
+PA0        = -5.0139195e-013     AGS        = 0.72524296          LAGS       = 8.690663e-008
+WAGS       = -1.3577595e-008     PAGS       = 2.0757627e-013      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.055738075        LKETA      = -3.8069646e-008     WKETA      = -3.74208e-010
+PKETA      = 3.342613e-015       DWG        = 0                   DWB        = 0
+PCLM       = 0.9178635           LPCLM      = -1.5956574e-007     WPCLM      = -2.6568768e-008
+PPCLM      = 2.3732552e-013      PDIBLC1    = 0                   PDIBLC2    = 0.0003682764
+LPDIBLC2   = 3.8179117e-009      WPDIBLC2   = 2.0119674e-009      PPDIBLC2   = -1.8551502e-015
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.31079287
+LKT1       = -6.8843972e-008     WKT1       = -2.9749536e-009     PKT1       = 2.6573773e-014
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.01227
+LUTE       = -2.4769778e-007     WUTE       = -2.5446144e-008     PUTE       = 2.2729768e-013
+UA1        = 4.3850173e-009      LUA1       = -7.0121674e-015     WUA1       = -2.8776595e-016
+PUA1       = 2.5704694e-021      UB1        = -7.3834013e-018     LUB1       = 1.0159465e-023
+WUB1       = 3.1135564e-025      PUB1       = -3.6568186e-030     UC1        = -1.233248e-010
+LUC1       = 2.083488e-016       WUC1       = 2.1198883e-017      PUC1       = -1.8935902e-022
+PRT        = 0                   AT         = 171432.2            LAT        = -0.10211815
+WAT        = -0.00187104         PAT        = 1.6713065e-008      JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.18 NMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = 3.96e-007       WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.34358333+dvthn_18'
+LVTH0      = '-1.9858781e-008+dlvthn_18'
+WVTH0      = '-9.0356167e-009+dwvthn_18'
+PVTH0      = '1.1607741e-014+dpvthn_18'
+K1         = 0.2398              K2         = 0.049597226         LK2        = -4.4092168e-009
+WK2        = 1.415722e-009       PK2        = -2.9019353e-016     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.057130556        LVOFF      = -1.4373975e-008     WVOFF      = 1.0626794e-008
+PVOFF      = -1.5476988e-014     NFACTOR    = 1.140304            LNFACTOR   = 6.2053963e-008
+WNFACTOR   = 3.1638865e-008      PNFACTOR   = -3.28886e-014       ETA0       = 0.010361111
+WETA0      = -2.8413889e-009     ETAB       = -0.03               U0         = 846.69083
+LU0        = '-0.00047384943+dlu0n_18'
+WU0        = -9.1123342e-005     PU0        = 1.8185461e-010      UA         = 7.2555409e-010
+LUA        = -2.0209419e-015     WUA        = -2.8861423e-016     PUA        = 7.1096797e-022
+UB         = 3.7881461e-018      LUB        = -8.8301948e-025     WUB        = -2.1287099e-025
+PUB        = 3.2613304e-031      UC         = 3.1693625e-010      LUC        = -1.9312192e-016
+WUC        = -8.0527803e-017     PUC        = 8.1641114e-023      VSAT       = '77000+dvsatn_18'
+A0         = 1.8195528           LA0        = -2.6100112e-008     WA0        = -1.9889722e-009
+PA0        = -1.1607741e-013     AGS        = 0.92960375          LAGS       = -1.2552641e-007
+WAGS       = -1.6749987e-008     PAGS       = 2.1087397e-013      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.11908875         LKETA      = 2.7783381e-008      WKETA      = 1.2146938e-008
+PKETA      = -9.6731178e-015     DWG        = 0                   DWB        = 0
+PCLM       = 0.41792069          LPCLM      = 3.6012481e-007      WPCLM      = 5.3115503e-007
+PPCLM      = -3.4242837e-013     PDIBLC1    = 0                   PDIBLC2    = 0.0029221528
+LPDIBLC2   = 1.1631572e-009      WPDIBLC2   = -5.5435497e-010     PPDIBLC2   = 8.1254189e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.45368312
+LKT1       = 7.9690452e-008      WKT1       = 5.2180686e-008      PKT1       = -3.0760515e-014
+KT1L       = 0                   KT2        = -0.03076            UTE        = -3.6925381
+LUTE       = 1.4989408e-006      WUTE       = 5.6171417e-007      PUTE       = -3.8305546e-013
+UA1        = -5.4256396e-009     LUA1       = 3.1860105e-015      WUA1       = 2.8978331e-015
+PUA1       = -7.4096082e-022     UB1        = 2.6639313e-018      LUB1       = -2.847371e-025
+WUB1       = -3.5322016e-024     PUB1       = 3.3855912e-031      UC1        = 4.0081704e-010
+LUC1       = -3.3649665e-016     WUC1       = -3.7182841e-016     PUC1       = 2.1919285e-022
+PRT        = 0                   AT         = 84229.375           LAT        = -0.01147081
+WAT        = 0.035609706         PAT        = -2.2248171e-008     JSS        = 1.699E-07
+JSD        = 1.699E-07           JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 8.5E-13             JSWGD      = 8.5E-13             NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.1
+IJTHSREV   = 0.01                IJTHDREV   = 0.1                 BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.6                 PBD        = 0.6                 CJS        = 'cjn_18'
+CJD        = 'cjn_18'            MJS        = 0.3                 MJD        = 0.3
+PBSWS      = 0.65                PBSWD      = 0.65                CJSWS      = 'cjswn_18'
+CJSWD      = 'cjswn_18'          MJSWS      = 0.067               MJSWD      = 0.067
+PBSWGS     = 0.47                 PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'
+CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38                MJSWGD     = 0.38
+TPB        = 1E-03               TCJ        = 1.14E-03            TPBSW      = 2E-03
+TCJSW      = 4E-04               TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 6.611e-008
+JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32               XTSSWGS    = 0.2464
+XTSSWGD    = 0.2464              TNJTSSWG   = 0.8                 VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL nch_18.19 NMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = 3.96e-007       WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.3038559+dvthn_18'
+LVTH0      = '3.5605391e-009+dlvthn_18'
+WVTH0      = '2.3263872e-008+dwvthn_18'
+PVTH0      = '-7.432807e-015+dpvthn_18'
+K1         = 0.24040481          LK1        = -3.5653833e-010     WK1        = 2.6898481e-009
+PK1        = -1.5856655e-015     K2         = 0.051052956         LK2        = -5.2673694e-009
+WK2        = -2.01857e-009       PK2        = 1.7343216e-015      K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.033128704        LVOFF      = -2.8523067e-008     WVOFF      = -3.0421804e-008
+PVOFF      = 8.7211602e-015      NFACTOR    = 1.1264965           LNFACTOR   = 7.0193484e-008
+WNFACTOR   = 5.1500174e-008      PNFACTOR   = -4.4596842e-014     ETA0       = 0.010361111
+WETA0      = -2.8413889e-009     ETAB       = -0.03               U0         = -214.91088
+LU0        = '0.00015196478+dlu0n_18'
+WU0        = 0.00036026443       PU0        = -8.4238479e-011     UA         = -5.3142908e-009
+LUA        = 1.5395467e-015      WUA        = 2.1662919e-015      PUA        = -7.3619921e-022
+UB         = 3.8924396e-018      LUB        = -9.445005e-025      WUB        = -2.4386762e-025
+PUB        = 3.4440555e-031      UC         = -4.3900694e-012     LUC        = -3.7000541e-018
+WUC        = 7.5616462e-017      PUC        = -1.040593e-023      VSAT       = '77000+dvsatn_18'
+A0         = 3.436686            LA0        = -9.7940014e-007     WA0        = -3.8937209e-007
+PA0        = 1.1228494e-013      AGS        = 2.6239699           LAGS       = -1.1243553e-006
+WAGS       = -1.4914924e-006     PAGS       = 1.0802346e-012      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.14202153         LKETA      = 4.1302253e-008      WKETA      = 2.0955243e-008
+PKETA      = -1.4865614e-014     DWG        = 0                   DWB        = 0
+PCLM       = 1.2859561           LPCLM      = -1.5158208e-007     WPCLM      = -5.7625734e-008
+PPCLM      = 4.6578924e-015      PDIBLC1    = 0                   PDIBLC2    = 0.0041828947
+LPDIBLC2   = 4.1994984e-010      WPDIBLC2   = 3.0448087e-009      PPDIBLC2   = -1.3091651e-015
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.3185
+KT1L       = 0                   KT2        = -0.03076            UTE        = -2.2258582
+LUTE       = 6.3433304e-007      WUTE       = 2.6378271e-007      PUTE       = -2.0742487e-013
+UA1        = -4.3265671e-009     LUA1       = 2.5381073e-015      WUA1       = 3.3119702e-015
+PUA1       = -9.8509468e-022     UB1        = 6.7087773e-018      LUB1       = -2.6691739e-024
+WUB1       = -5.018982e-024      PUB1       = 1.2150162e-030      UC1        = -1.9366667e-010
+LUC1       = 1.39515e-017        PRT        = 0                   AT         = 73640.41
+LAT        = -0.0052286153       WAT        = 0.0093176245        PAT        = -6.7489887e-009
+JSS        = 1.699E-07           JSD        = 1.699E-07           JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 8.5E-13             JSWGD      = 8.5E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.1                 IJTHSREV   = 0.01                IJTHDREV   = 0.1
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.6                 PBD        = 0.6
+CJS        = 'cjn_18'            CJD        = 'cjn_18'            MJS        = 0.3
+MJD        = 0.3                 PBSWS      = 0.65                PBSWD      = 0.65
+CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'          MJSWS      = 0.067
+MJSWD      = 0.067               PBSWGS     = 0.47                 PBSWGD     = 0.47
+CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'         MJSWGS     = 0.38
+MJSWGD     = 0.38                TPB        = 1E-03               TCJ        = 1.14E-03
+TPBSW      = 2E-03               TCJSW      = 4E-04               TPBSWG     = 1.50E-03
+TCJSWG     = 2.01E-03            XTIS       = 3                   XTID       = 3
+JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008          NJTSSWG    = 13.32
+XTSSWGS    = 0.2464              XTSSWGD    = 0.2464              TNJTSSWG   = 0.8
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBSB       = 50                  )

.MODEL nch_18.20 NMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = 3.96e-007       WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxn_18'           TOXM       = 3.45e-009           DTOX       = 3.166e-010
+EPSROX     = 3.9                 WINT       = 5e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.05009e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '0.30550338+dvthn_18'
+LVTH0      = '3.0341703e-009+dlvthn_18'
+WVTH0      = '5.0332089e-009+dwvthn_18'
+PVTH0      = '-1.6081103e-015+dpvthn_18'
+K1         = 0.23892674          LK1        = 1.1570722e-010      WK1        = -3.883738e-009
+PK1        = 5.1459528e-016      K2         = 0.020916136         LK2        = 4.3613447e-009
+WK2        = 4.2753786e-009      PK2        = -2.7659496e-016     K3         = -0.6
+K3B        = 2.7                 W0         = 1e-007              DVT0       = 0.3
+DVT1       = 0.087               DVT2       = 0.05                DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.3
+MINV       = 0                   VOFFL      = -5e-009             DVTP0      = 6.901921e-007
+DVTP1      = 5                   LPE0       = 6.6e-007            LPEB       = 2.1e-007
+XJ         = 1.4e-007            NGATE      = 3.046e+020          NDEP       = 8e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 1e-008
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10721311         LVOFF      = -4.8531004e-009     WVOFF      = -5.8434606e-009
+PVOFF      = 8.6837954e-016      NFACTOR    = 1.6355786           LNFACTOR   = -9.2458243e-008
+WNFACTOR   = -9.8753458e-008     PNFACTOR   = 3.4091937e-015      ETA0       = 0.010361111
+WETA0      = -2.8413889e-009     ETAB       = -0.03               U0         = 164.98647
+LU0        = '3.0587573e-005+dlu0n_18'
+WU0        = 0.00017851656       PU0        = -2.6170032e-011     UA         = -3.4130894e-010
+LUA        = -4.9321044e-017     WUA        = -1.6301305e-016     PUA        = 8.013728e-024
+UB         = -2.5352267e-019     LUB        = 3.8013446e-025      WUB        = 1.5277569e-024
+PUB        = -2.2162847e-031     UC         = -2.0028351e-010     LUC        = 5.88879e-017
+WUC        = 1.2332672e-016      PUC        = -2.5649359e-023     VSAT       = '75100.676+dvsatn_18'
+LVSAT      = 0.00060683406       WVSAT      = 0.0010066418        PVSAT      = -3.2162205e-010
+A0         = -1.5350749          LA0        = 6.0907746e-007      WA0        = 3.6860943e-008
+PA0        = -2.3896518e-014     AGS        = -3.0060458          LAGS       = 6.7443474e-007
+WAGS       = 3.2786893e-006      PAGS       = -4.4383843e-013     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.04205667         LKETA      = 9.3634809e-009      WKETA      = -2.3559216e-008
+PKETA      = -6.432441e-016      DWG        = 0                   DWB        = 0
+PCLM       = 1.1697796           LPCLM      = -1.1446368e-007     WPCLM      = -1.0475418e-007
+PPCLM      = 1.9715432e-014      PDIBLC1    = 0                   PDIBLC2    = 0.0064730817
+LPDIBLC2   = -3.1176493e-010     WPDIBLC2   = -1.5469957e-009     PPDIBLC2   = 1.5791643e-016
+PDIBLCB    = 0                   DROUT      = 0.56                PVAG       = 0
+DELTA      = 0.015               PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 1000                PDITS      = 0.034               PDITSD     = 0.4
+PDITSL     = 0                   RSH        = 11.58               RDSW       = 200
+RSW        = 89                  RDW        = 89                  PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 1.684e-007
+ALPHA1     = 5.889               BETA0      = 16.3                AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgon_18'           CGDO       = 'cgon_18'           CGBO       = 0
+CGDL       = 'cgln_18'           CGSL       = 'cgln_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfn_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.07                MOIN       = 15
+NOFF       = 1.29                VOFFCV     = -0.14               KT1        = -0.37263369
+LKT1       = 1.7295714e-008      KT1L       = 0                   KT2        = -0.03076
+UTE        = 0.39966108          LUTE       = -2.0452037e-007     WUTE       = -7.5436862e-007
+PUTE       = 1.1787448e-013      UA1        = 4.3440057e-009      LUA1       = -2.3214075e-016
+WUA1       = 3.9080113e-016      PUA1       = -5.178115e-023      UB1        = -1.1150508e-018
+LUB1       = -1.6946077e-025     WUB1       = -2.0777998e-024     PUB1       = 2.7530848e-031
+UC1        = -1.1457219e-010     LUC1       = -1.1319184e-017     PRT        = 0
+AT         = 102344.21           LAT        = -0.01439948         WAT        = -0.02653314
+PAT        = 4.7053306e-009      JSS        = 1.699E-07           JSD        = 1.699E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 8.5E-13
+JSWGD      = 8.5E-13             NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.1                 IJTHSREV   = 0.01
+IJTHDREV   = 0.1                 BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.6
+PBD        = 0.6                 CJS        = 'cjn_18'            CJD        = 'cjn_18'
+MJS        = 0.3                 MJD        = 0.3                 PBSWS      = 0.65
+PBSWD      = 0.65                CJSWS      = 'cjswn_18'          CJSWD      = 'cjswn_18'
+MJSWS      = 0.067               MJSWD      = 0.067               PBSWGS     = 0.47
+PBSWGD     = 0.47                 CJSWGS     = 'cjswgn_18'         CJSWGD     = 'cjswgn_18'
+MJSWGS     = 0.38                MJSWGD     = 0.38                TPB        = 1E-03
+TCJ        = 1.14E-03            TPBSW      = 2E-03               TCJSW      = 4E-04
+TPBSWG     = 1.50E-03            TCJSWG     = 2.01E-03            XTIS       = 3
+XTID       = 3                   JTSSWGS    = 6.611e-008          JTSSWGD    = 6.611e-008
+NJTSSWG    = 13.32               XTSSWGS    = 0.2464              XTSSWGD    = 0.2464
+TNJTSSWG   = 0.8                 VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+SAREF      = 0.738E-6            SBREF      = 0.738E-6
+KVSAT      = 0.2                 WLOD       = 3E-7                TKU0       = 0.1
+KU0        = -5.0E-8             LLODKU0    = 1                   WLODKU0    = 1
+LKU0       = 4.1E-7              WKU0       = 8.0E-7              PKU0       = 6E-14
+KVTH0      = 4.3E-9              STK2       = 0.6E-9              STETA0     = 0
+LKVTH0     = -1E-8               WKVTH0     = 1.5E-6              PKVTH0     = 0
+LLODVTH    = 1                   WLODVTH    = 1                   LODK2      = 1
+LODETA0    = 1
+TTDIOMOD   = 1
+RBDB       = 50                  RBSB       = 50                  )
**********************************************************************************************
*                                                                                            *
*                                   1.8V PMOS DEVICE MODELS                                    *
*                                                                                            *
**********************************************************************************************

.MODEL pch_18.1 PMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.024               K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.1147958          NFACTOR    = 0.3251818           ETA0       = 0.03
+ETAB       = -0.071              U0         = '120.48+du0p_18'    UA         = 7.422834e-010
+UB         = 1.45537e-018        UC         = -1e-011             VSAT       = '113850+dvsatp_18'
+A0         = 1.997306            AGS        = 0.587925            A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.0572             DWG        = 0                   DWB        = 0
+PCLM       = 0.69                PDIBLC1    = 0                   PDIBLC2    = 0.000290971
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.25
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.9783054
+UA1        = 3.267925e-009       UB1        = -4.56691e-018       UC1        = -6.896e-012
+PRT        = 0                   AT         = 158500              JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+TTDIOMOD      = 1
+WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.2 PMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.023453449         LK2        = 4.8820645e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11355142         LVOFF      = -1.1115461e-008
+NFACTOR    = 0.23524955          LNFACTOR   = 8.0331983e-007      ETA0       = 0.03
+ETAB       = -0.071              U0         = '118.89698+du0p_18' LU0        = 1.4140341e-005
+UA         = 7.0543447e-010      LUA        = 3.2915302e-016      UB         = 1.4643939e-018
+LUB        = -8.0605826e-026     UC         = -1.3134436e-011     LUC        = 2.7998346e-017
+VSAT       = '113850+dvsatp_18'  A0         = 2.0264473           LA0        = -2.6030462e-007
+AGS        = 0.5626701           LAGS       = 2.2558938e-007      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.054934778        LKETA      = -2.0234099e-008     DWG        = 0
+DWB        = 0                   PCLM       = 0.41343216          LPCLM      = 2.4704423e-006
+PDIBLC1    = 0                   PDIBLC2    = -0.00023644902      LPDIBLC2   = 4.7111793e-009
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.24249316
+LKT1       = -6.7054862e-008     KT1L       = 0                   KT2        = -0.03924
+UTE        = -0.96316376         LUTE       = -1.3525271e-007     UA1        = 3.1556319e-009
+LUA1       = 1.0030584e-015      UB1        = -4.2392327e-018     LUB1       = -2.9269777e-024
+UC1        = -6.896e-012         PRT        = 0                   AT         = 158500
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.3 PMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.030901            LK2        = -2.8596645e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.10177079         LVOFF      = -2.3361416e-008
+NFACTOR    = 1.2402336           LNFACTOR   = -2.4136113e-007     ETA0       = 0.03
+ETAB       = -0.071              U0         = '131.845+du0p_18'   LU0        = 6.808725e-007
+UA         = 1.006605e-009       LUA        = 1.6086294e-017      UB         = 1.4218686e-018
+LUB        = -3.6400806e-026     UC         = 1.38e-011           VSAT       = '113850+dvsatp_18'
+A0         = 1.9647185           LA0        = -1.9613758e-007     AGS        = 0.52474466
+LAGS       = 2.6501287e-007      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.059728
+LKETA      = -1.5251544e-008     DWG        = 0                   DWB        = 0
+PCLM       = 4.1                 LPCLM      = -1.361745e-006      PDIBLC1    = 0
+PDIBLC2    = 0.0021495501        LPDIBLC2   = 2.2309332e-009      PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.25067            LKT1       = -5.8555035e-008
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.64431511
+LUTE       = -4.6669588e-007     UA1        = 5.946246e-009       LUA1       = -1.897785e-015
+UB1        = -7.5410858e-018     LUB1       = 5.0529863e-025      UC1        = -6.896e-012
+PRT        = 0                   AT         = 158500              JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50
+TTDIOMOD      = 1
+WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.4 PMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.0333275           LK2        = -4.2900863e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.14009833         LVOFF      = -7.673325e-010
+NFACTOR    = 0.62939667          LNFACTOR   = 1.1872727e-007      ETA0       = 0.03
+ETAB       = -0.071              U0         = '144.83333+du0p_18' LU0        = -6.97575e-006
+UA         = 1.2496014e-009      LUA        = -1.2716011e-016     UB         = 1.3791587e-018
+LUB        = -1.1223284e-026     UC         = 1.38e-011           VSAT       = '113850+dvsatp_18'
+A0         = 2.0923167           LA0        = -2.7135667e-007     AGS        = 0.57823833
+LAGS       = 2.3347835e-007      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.05862
+LKETA      = -1.590471e-008      DWG        = 0                   DWB        = 0
+PCLM       = 1.932               LPCLM      = -8.3709e-008        PDIBLC1    = 0
+PDIBLC2    = 0.00636             LPDIBLC2   = -2.51127e-010       PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.35               KT1L       = 0
+KT2        = -0.03924            UTE        = -2.1953228          LUTE       = 4.4762313e-007
+UA1        = 1.6999168e-009      LUA1       = 6.0542604e-016      UB1        = -8.6714619e-018
+LUB1       = 1.1716553e-024      UC1        = -6.896e-012         PRT        = 0
+AT         = 158500              JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_18'
+TTDIOMOD      = 1
+LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.5 PMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '9e-006-dxw_18'     WMAX       = 0.000900001
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.32582888+dvthp_18'
+LVTH0      = '-4.5276738e-009+dlvthp_18'
+K1         = 0.3173              K2         = 0.015216444         LK2        = 1.4963962e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12095989         LVOFF      = -6.8820642e-009
+NFACTOR    = 1.0806417           LNFACTOR   = -2.5445527e-008     ETA0       = 0.045103583
+LETA0      = -4.8255947e-009     ETAB       = -0.071              U0         = '141.08235+du0p_18'
+LU0        = -5.7773118e-006     UA         = 1.1961072e-009      LUA        = -1.100687e-016
+UB         = 1.3539728e-018      LUB        = -3.1763896e-027     UC         = 4.1079412e-011
+LUC        = -8.7157721e-018     VSAT       = '113814.57+dvsatp_18'
+LVSAT      = 1.1319184e-005      A0         = 1.5252888           LA0        = -9.0191262e-008
+AGS        = 0.46865241          LAGS       = 2.6849106e-007      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.12852299         LKETA      = 6.4292968e-009      DWG        = 0
+DWB        = 0                   PCLM       = 1.4198797           LPCLM      = 7.9913443e-008
+PDIBLC1    = 0                   PDIBLC2    = 0.0088149358        LPDIBLC2   = -1.035479e-009
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.35793583
+LKT1       = 2.5354973e-009      KT1L       = 0                   KT2        = -0.03924
+UTE        = -0.68307616         LUTE       = -3.5539659e-008     UA1        = 5.2066816e-009
+LUA1       = -5.1498531e-016     UB1        = -7.1146082e-018     LUB1       = 6.7424058e-025
+UC1        = -6.896e-012         PRT        = 0                   AT         = 220845.86
+LAT        = -0.019919501        JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+TTDIOMOD      = 1
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_18'       )

.MODEL pch_18.6 PMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.33966741+dvthp_18'
+WVTH0      = '-2.9926681e-009+dwvthp_18'
+K1         = 0.3173              K2         = 0.024               K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.11407208         WVOFF      = -6.5120459e-009     NFACTOR    = 0.33937998
+WNFACTOR   = -1.2775521e-007     ETA0       = 0.03                ETAB       = -0.071
+U0         = '119.46982+du0p_18' WU0        = 9.089631e-006       UA         = 7.4323026e-010
+WUA        = -8.519827e-018      UB         = 1.4698734e-018      WUB        = -1.3050128e-025
+UC         = -1.2017728e-011     WUC        = 1.815552e-017       VSAT       = '113850+dvsatp_18'
+A0         = 2.0024117           WA0        = -4.5941446e-008     AGS        = 0.58672354
+WAGS       = 1.0810714e-008      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.05751042
+WKETA      = 2.7931569e-009      DWG        = 0                   DWB        = 0
+PCLM       = 0.67478943          WPCLM      = 1.3686469e-007      PDIBLC1    = 0
+PDIBLC2    = 0.00023776151       WPDIBLC2   = 4.7877902e-010      PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.25077605         WKT1       = 6.9828923e-009
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.91553657
+WUTE       = -5.6479389e-007     UA1        = 3.551725e-009       WUA1       = -2.5536323e-015
+UB1        = -4.7883919e-018     WUB1       = 1.9928945e-024      UC1        = -6.896e-012
+PRT        = 0                   AT         = 162451.2            WAT        = -0.035552898
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.7 PMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.33962361+dvthp_18'
+LVTH0      = '-3.9126229e-010+dlvthp_18'
+WVTH0      = '-3.3867995e-009+dwvthp_18'
+PVTH0      = 3.5205781e-015      K1         = 0.3173              K2         = 0.023502362
+LK2        = 4.4451549e-009      WK2        = -4.4011331e-010     PK2        = 3.9313122e-015
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11266334         LVOFF      = -1.2583516e-008
+WVOFF      = -7.990866e-009      PVOFF      = 1.3209561e-014      NFACTOR    = 0.25072582
+LNFACTOR   = 7.9190323e-007      WNFACTOR   = -1.3925553e-007     PNFACTOR   = 1.0272659e-013
+ETA0       = 0.03                ETAB       = -0.071              U0         = '117.68805+du0p_18'
+LU0        = 1.5915615e-005      WU0        = 1.0877923e-005      PU0        = -1.5973919e-011
+UA         = 6.9952552e-010      LUA        = 3.903926e-016       WUA        = 5.3168806e-017
+PUA        = -5.5103372e-022     UB         = 1.4818295e-018      LUB        = -1.0679797e-025
+WUB        = -1.5688548e-025     PUB        = 2.3567688e-031      UC         = -1.5417897e-011
+LUC        = 3.0372004e-017      WUC        = 2.0546583e-017      PUC        = -2.1358174e-023
+VSAT       = '113850+dvsatp_18'  A0         = 2.0332338           LA0        = -2.7531788e-007
+WA0        = -6.1064791e-008     PA0        = 1.3508927e-013      AGS        = 0.56145391
+LAGS       = 2.25721e-007        WAGS       = 1.09433e-008        PAGS       = -1.1843225e-015
+A1         = 0                   A2         = 0.99                B0         = 0
+B1         = 0                   KETA       = -0.055286079        LKETA      = -1.986892e-008
+WKETA      = 3.1610128e-009      PKETA      = -3.2858728e-015     DWG        = 0
+DWB        = 0                   PCLM       = 0.41695137          LPCLM      = 2.3031385e-006
+WPCLM      = -3.1665864e-008     PPCLM      = 1.5053992e-012      PDIBLC1    = 0
+PDIBLC2    = -0.00027382037      LPDIBLC2   = 4.5697051e-009      WPDIBLC2   = 3.3626744e-010
+PPDIBLC2   = 1.2729847e-015      PDIBLCB    = 0                   DROUT      = 0.4800472
+PVAG       = 0                   DELTA      = 0.01                PSCBE1     = 4e+008
+PSCBE2     = 1e-006              FPROUT     = 0                   PDITS      = 0.06
+PDITSD     = 0.46                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 8.242e-007          ALPHA1     = 2.999163            BETA0      = 20.74914
+AGIDL      = 1.488e-008          BGIDL      = 2.18e+009           CGIDL      = 0.636
+EGIDL      = 0.09287             AIGBACC    = 0.43                BIGBACC    = 0.054
+CIGBACC    = 0.075               NIGBACC    = 1                   AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 3                   AIGC       = 0.43                BIGC       = 0.054
+CIGC       = 0.075               AIGSD      = 0.43                BIGSD      = 0.054
+CIGSD      = 0.075               NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 1                   NTOX       = 1                   XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_18'           CGDO       = 'cgop_18'
+CGBO       = 0                   CGDL       = 'cglp_18'           CGSL       = 'cglp_18'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_18'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.404
+MOIN       = 12.6                NOFF       = 1.228               VOFFCV     = -0.0549
+KT1        = -0.24337141         LKT1       = -6.6141916e-008     WKT1       = 7.9025321e-009
+PKT1       = -8.2146821e-015     KT1L       = 0                   KT2        = -0.03924
+UTE        = -0.88998848         LUTE       = -2.2820839e-007     WUTE       = -6.5843119e-007
+PUTE       = 8.3641518e-013      UA1        = 3.4660085e-009      LUA1       = 7.6566214e-016
+WUA1       = -2.7927693e-015     PUA1       = 2.1360914e-021      UB1        = -4.459019e-018
+LUB1       = -2.9421234e-024     WUB1       = 1.9776377e-024      PUB1       = 1.3628158e-031
+UC1        = -6.896e-012         PRT        = 0                   AT         = 162451.2
+WAT        = -0.035552898        JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+TTDIOMOD      = 1
+RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_18.8 PMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.030181048         LK2        = -2.4973395e-009
+WK2        = 6.478129e-009       PK2        = -3.2602007e-015     K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.10065798         LVOFF      = -2.5063091e-008     WVOFF      = -1.0013096e-008
+PVOFF      = 1.5311668e-014      NFACTOR    = 1.2937766           LNFACTOR   = -2.9234804e-007
+WNFACTOR   = -4.8177944e-007     PNFACTOR   = 4.587802e-013       ETA0       = 0.03
+ETAB       = -0.071              U0         = '131.54511+du0p_18' LU0        = 1.5112007e-006
+WU0        = 2.6983891e-006      PU0        = -7.4712933e-012     UA         = 1.0432546e-009
+LUA        = 3.3086192e-017      WUA        = -3.297736e-016      PUA        = -1.5296509e-022
+UB         = 1.4208352e-018      LUB        = -4.3394434e-026     WUB        = 9.2984693e-027
+PUB        = 6.2928666e-032      UC         = 1.38e-011           VSAT       = '113850+dvsatp_18'
+A0         = 1.9460955           LA0        = -1.8473763e-007     WA0        = 1.6757018e-007
+PA0        = -1.0257678e-013     AGS        = 0.5196679           LAGS       = 2.6915755e-007
+WAGS       = 4.5680694e-008      PAGS       = -3.7293843e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.059728           LKETA      = -1.5251544e-008     DWG        = 0
+DWB        = 0                   PCLM       = 4.6905181           LPCLM      = -2.1392341e-006
+WPCLM      = -5.3134823e-006     PPCLM      = 6.9958474e-012      PDIBLC1    = 0
+PDIBLC2    = 0.0016131884        LPDIBLC2   = 2.6081595e-009      WPDIBLC2   = 4.8261824e-009
+PPDIBLC2   = -3.3942819e-015     PDIBLCB    = 0                   DROUT      = 0.4800472
+PVAG       = 0                   DELTA      = 0.01                PSCBE1     = 4e+008
+PSCBE2     = 1e-006              FPROUT     = 0                   PDITS      = 0.06
+PDITSD     = 0.46                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 8.242e-007          ALPHA1     = 2.999163            BETA0      = 20.74914
+AGIDL      = 1.488e-008          BGIDL      = 2.18e+009           CGIDL      = 0.636
+EGIDL      = 0.09287             AIGBACC    = 0.43                BIGBACC    = 0.054
+CIGBACC    = 0.075               NIGBACC    = 1                   AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 3                   AIGC       = 0.43                BIGC       = 0.054
+CIGC       = 0.075               AIGSD      = 0.43                BIGSD      = 0.054
+CIGSD      = 0.075               NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 1                   NTOX       = 1                   XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_18'           CGDO       = 'cgop_18'
+CGBO       = 0                   CGDL       = 'cglp_18'           CGSL       = 'cglp_18'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_18'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.404
+MOIN       = 12.6                NOFF       = 1.228               VOFFCV     = -0.0549
+KT1        = -0.24645827         LKT1       = -6.2933129e-008     WKT1       = -3.7897154e-008
+PKT1       = 3.9394092e-014      KT1L       = 0                   KT2        = -0.03924
+UTE        = -0.62818381         LUTE       = -5.0035434e-007     WUTE       = -1.4514943e-007
+PUTE       = 3.0285879e-013      UA1        = 6.1263187e-009      LUA1       = -1.9997303e-015
+WUA1       = -1.6202943e-015     PUA1       = 9.1730366e-022      UB1        = -7.7510145e-018
+LUB1       = 4.7990584e-025      WUB1       = 1.8889385e-024      PUB1       = 2.2848437e-031
+UC1        = -6.896e-012         PRT        = 0                   AT         = 162451.2
+WAT        = -0.035552898        JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_18'
+TTDIOMOD      = 1
+LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.9 PMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.033766615         LK2        = -4.611031e-009
+WK2        = -3.9511533e-009     PK2        = 2.8878612e-015      K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.14231643         LVOFF      = -5.0543382e-010     WVOFF      = 1.9958461e-008
+PVOFF      = -2.3565643e-015     NFACTOR    = 0.57894508          LNFACTOR   = 1.2904514e-007
+WNFACTOR   = 4.5396342e-007      PNFACTOR   = -9.2840213e-014     ETA0       = 0.03
+ETAB       = -0.071              U0         = '145.17283+du0p_18' LU0        = -6.5223362e-006
+WU0        = -3.054751e-006      PU0        = -4.0798172e-012     UA         = 1.2969889e-009
+LUA        = -1.1649018e-016     WUA        = -4.2639288e-016     PUA        = -9.6008023e-023
+UB         = 1.3664106e-018      LUB        = -1.1311138e-026     WUB        = 1.1470671e-025
+PUB        = 7.905085e-034       UC         = 1.4626493e-011      LUC        = -4.8721738e-019
+WUC        = -7.4367803e-018     PUC        = 4.383982e-024       VSAT       = '113850+dvsatp_18'
+A0         = 2.142163            LA0        = -3.0031943e-007     WA0        = -4.4851741e-007
+PA0        = 2.6060685e-013      AGS        = 0.56779331          LAGS       = 2.4078763e-007
+WAGS       = 9.3984346e-008      PAGS       = -6.5768846e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.05715068         LKETA      = -1.6770874e-008     WKETA      = -1.3220943e-008
+PKETA      = 7.7937458e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.91894144          LPCLM      = 8.4110321e-008      WPCLM      = 9.1155009e-006
+PPCLM      = -1.5100382e-012     PDIBLC1    = 0                   PDIBLC2    = 0.0065861344
+LPDIBLC2   = -3.2339217e-010     WPDIBLC2   = -2.0347571e-009     PPDIBLC2   = 6.5024195e-016
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.3551829
+LKT1       = 1.1600414e-009      WKT1       = 4.6635745e-008      PKT1       = -1.0438052e-014
+KT1L       = 0                   KT2        = -0.03924            UTE        = -2.3006151
+LUTE       = 4.8554391e-007      WUTE       = 9.4742047e-007      PUTE       = -3.4121117e-013
+UA1        = 1.5847142e-009      LUA1       = 6.7754558e-016      WUA1       = 1.0365934e-015
+PUA1       = -6.4893163e-022     UB1        = -9.043058e-018      LUB1       = 1.2415655e-024
+WUB1       = 3.3436216e-024      PUB1       = -6.2905132e-031     UC1        = -6.896e-012
+PRT        = 0                   AT         = 162451.2            WAT        = -0.035552898
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.10 PMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '9e-007-dxw_18'     WMAX       = '9e-006-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.32520045+dvthp_18'
+LVTH0      = '-4.7284566e-009+dlvthp_18'
+WVTH0      = '-5.6545958e-009+dwvthp_18'
+PVTH0      = 1.8066434e-015      K1         = 0.3173              K2         = 0.014995886
+LK2        = 1.3862166e-009      WK2        = 1.9845764e-009      PK2        = 9.9139554e-016
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12143241         LVOFF      = -7.1778799e-009
+WVOFF      = 4.2516866e-009      PVOFF      = 2.6617502e-015      NFACTOR    = 1.0948178
+LNFACTOR   = -3.5776202e-008     WNFACTOR   = -1.2755654e-007     PNFACTOR   = 9.2955414e-014
+ETA0       = 0.045015289         LETA0      = -4.7973848e-009     WETA0      = 7.9447071e-010
+PETA0      = -2.5383339e-016     ETAB       = -0.071              U0         = '143.65659+du0p_18'
+LU0        = -6.0379002e-006     WU0        = -2.316302e-005      PU0        = 2.3447747e-012
+UA         = 1.3181756e-009      LUA        = -1.2325933e-016     WUA        = -1.098372e-015
+PUA        = 1.1868931e-022      UB         = 1.3112983e-018      LUB        = 6.2972442e-027
+WUB        = 3.8398453e-025      PUB        = -8.5243757e-032     UC         = 3.8401419e-011
+LUC        = -8.0833063e-018     WUC        = 2.409658e-017       PUC        = -5.6909266e-024
+VSAT       = '114427.29+dvsatp_18'
+LVSAT      = -0.00018444402      WVSAT      = -0.0055132309       PVSAT      = 1.7614773e-009
+A0         = 1.4576154           LA0        = -8.1606468e-008     WA0        = 6.0892493e-007
+PA0        = -7.7245972e-014     AGS        = 0.30441297          LAGS       = 3.2493764e-007
+WAGS       = 1.4778264e-006      PAGS       = -5.0790639e-013     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.12816218         LKETA      = 5.9173007e-009      WKETA      = -3.2465915e-009
+PKETA      = 4.6069406e-015      DWG        = 0                   DWB        = 0
+PCLM       = 0.67418604          LPCLM      = 1.6230967e-007      WPCLM      = 6.7097514e-006
+PPCLM      = -7.4140127e-013     PDIBLC1    = 0                   PDIBLC2    = 0.0088148544
+LPDIBLC2   = -1.0354682e-009     WPDIBLC2   = 7.3288362e-013      PPDIBLC2   = -9.710708e-020
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.36374553
+LKT1       = 3.8958006e-009      WKT1       = 5.2275671e-008      PKT1       = -1.2240009e-014
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.64767555
+LUTE       = -4.2570278e-008     WUTE       = -3.1853471e-007     PUTE       = 6.3261514e-014
+UA1        = 5.4342091e-009      LUA1       = -5.5236805e-016     WUA1       = -2.0472925e-015
+PUA1       = 3.3636989e-022      UB1        = -7.4106714e-018     LUB1       = 7.2001797e-025
+WUB1       = 2.6639774e-024      PUB1       = -4.1190497e-031     UC1        = -6.896e-012
+PRT        = 0                   AT         = 227820.58           LAT        = -0.020885517
+WAT        = -0.062758572        PAT        = 8.6922128e-009      JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+TTDIOMOD      = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_18.11 PMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34748333+dvthp_18'
+WVTH0      = '4.0260333e-009+dwvthp_18'
+K1         = 0.3173              K2         = 0.021011111         WK2        = 2.6840222e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12506425         WVOFF      = 3.3589196e-009
+NFACTOR    = 0.21350855          WNFACTOR   = -1.4722667e-008     ETA0       = 0.03
+ETAB       = -0.071              U0         = '137.24899+du0p_18' WU0        = -6.8760623e-006
+UA         = 1.1302465e-009      WUA        = -3.5606037e-016     UB         = 1.2829272e-018
+WUB        = 3.7376351e-026      UC         = 8.2e-012            VSAT       = '113850+dvsatp_18'
+A0         = 1.8068588           WA0        = 1.2966511e-007      AGS        = 0.59836617
+WAGS       = 3.5563294e-010      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.063366667
+WKETA      = 8.0520667e-009      DWG        = 0                   DWB        = 0
+PCLM       = -0.28287333         WPCLM      = 9.9684585e-007      PDIBLC1    = 0
+PDIBLC2    = 0.00042858015       WPDIBLC2   = 3.0742388e-010      PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.21161667         WKT1       = -2.8182233e-008
+KT1L       = 0                   KT2        = -0.03924            UTE        = -2.0592937
+WUTE       = 4.6230001e-007      UA1        = -2.118818e-009      WUA1       = 2.5385153e-015
+UB1        = -8.6158078e-019     WUB1       = -1.5333819e-024     UC1        = -6.896e-012
+PRT        = 0                   AT         = 161327              WAT        = -0.034543366
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.12 PMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34846888+dvthp_18'
+LVTH0      = '8.8034014e-009+dlvthp_18'
+WVTH0      = '4.5562578e-009+dwvthp_18'
+PVTH0      = -4.73623e-015       K1         = 0.3173              K2         = 0.019728144
+LK2        = 1.1460107e-008      WK2        = 2.9491345e-009      PK2        = -2.368115e-015
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12579492         LVOFF      = 6.5267261e-009
+WVOFF      = 3.8012859e-009      PVOFF      = -3.9514367e-015     NFACTOR    = 0.11420701
+LNFACTOR   = 8.8701106e-007      WNFACTOR   = -1.6661627e-008     PNFACTOR   = 1.7319762e-014
+ETA0       = 0.03                ETAB       = -0.071              U0         = '139.01485+du0p_18'
+LU0        = -1.5773565e-005     WU0        = -8.2735396e-006     PU0        = 1.2482966e-011
+UA         = 1.2220005e-009      LUA        = -8.1959272e-016     WUA        = -4.160137e-016
+PUA        = 5.355331e-022       UB         = 1.2279229e-018      LUB        = 4.9132655e-025
+WUB        = 7.1122664e-026      PUB        = -3.0143894e-031     UC         = 7.4624857e-012
+LUC        = 6.5878461e-018      VSAT       = '113850+dvsatp_18'  A0         = 1.8076726
+LA0        = -7.2697666e-009     WA0        = 1.4148912e-007      PA0        = -1.0561793e-013
+AGS        = 0.57574781          LAGS       = 2.020385e-007       WAGS       = -1.8926248e-009
+PAGS       = 2.0082562e-014      A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.059630513
+LKETA      = -3.3373192e-008     WKETA      = 7.0623143e-009      PKETA      = 8.8409626e-015
+DWG        = 0                   DWB        = 0                   PCLM       = -0.71909487
+LPCLM      = 3.8965489e-006      WPCLM      = 9.8850366e-007      PPCLM      = 7.4516685e-014
+PDIBLC1    = 0                   PDIBLC2    = -0.000273011        LPDIBLC2   = 6.2669629e-009
+WPDIBLC2   = 3.3554062e-010      PPDIBLC2   = -2.511528e-016      PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.19905478         LKT1       = -1.1220906e-007
+WKT1       = -3.1893805e-008     PKT1       = 3.315361e-014       KT1L       = 0
+KT2        = -0.03924            UTE        = -2.2058188          LUTE       = 1.3088355e-006
+WUTE       = 5.2318445e-007      PUTE       = -5.4385024e-013     UA1        = -2.8431278e-009
+LUA1       = 6.4698977e-015      WUA1       = 2.8728352e-015      PUA1       = -2.9863122e-021
+UB1        = -3.2431478e-019     LUB1       = -4.7991285e-024     WUB1       = -1.7353267e-024
+PUB1       = 1.8038721e-030      UC1        = -6.896e-012         PRT        = 0
+AT         = 161327              WAT        = -0.034543366        JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+TTDIOMOD      = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_18.13 PMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.045457528         LK2        = -1.5285588e-008
+WK2        = -7.2401499e-009     PK2        = 8.2236461e-015      K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.12198858         LVOFF      = 2.5700365e-009      WVOFF      = 9.1417797e-009
+PVOFF      = -9.50288e-015       NFACTOR    = 0.83558276          LNFACTOR   = 1.3714096e-007
+WNFACTOR   = -7.0321382e-008     PNFACTOR   = 7.3099077e-014      ETA0       = 0.03
+ETAB       = -0.071              U0         = '119.96344+du0p_18' LU0        = 4.0303703e-006
+WU0        = 1.3098729e-005      PU0        = -9.7335076e-012     UA         = -6.5195227e-011
+LUA        = 5.1844721e-016      WUA        = 6.6561437e-016      PUA        = -5.8881928e-022
+UB         = 2.0595783e-018      LUB        = -3.7317928e-025     WUB        = -5.6429282e-025
+PUB        = 3.5907546e-031      UC         = 1.6540811e-011      LUC        = -2.8490731e-018
+WUC        = -2.4612484e-018     PUC        = 2.5584677e-024      VSAT       = '113850+dvsatp_18'
+A0         = 2.2991937           LA0        = -5.1820592e-007     WA0        = -1.4951201e-007
+PA0        = 1.9687774e-013      AGS        = 0.45841388          LAGS       = 3.2400712e-007
+WAGS       = 1.0068681e-007      PAGS       = -8.6548759e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.083328267        LKETA      = -8.7393768e-009     WKETA      = 2.1193039e-008
+PKETA      = -5.8479261e-015     DWG        = 0                   DWB        = 0
+PCLM       = -10.668699          LPCLM      = 1.4239162e-005      WPCLM      = 8.4790946e-006
+PPCLM      = -7.7119526e-012     PDIBLC1    = 0                   PDIBLC2    = 0.010256125
+LPDIBLC2   = -4.6780737e-009     WPDIBLC2   = -2.9351745e-009     PPDIBLC2   = 3.1487555e-015
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.34543394
+LKT1       = 3.9952085e-008      WKT1       = 5.0983002e-008      PKT1       = -5.2996831e-014
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.91967195
+LUTE       = -2.8114164e-008     WUTE       = 1.1660692e-007      PUTE       = -1.2121289e-013
+UA1        = 4.0628638e-009      LUA1       = -7.0888062e-016     WUA1       = 2.3268818e-016
+PUA1       = -2.4187936e-022     UB1        = -5.0198659e-018     LUB1       = 8.1896888e-026
+WUB1       = -5.6363291e-025     PUB1       = 5.8589641e-031      UC1        = -6.896e-012
+PRT        = 0                   AT         = 161327              WAT        = -0.034543366
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.14 PMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_18'
+TOXM       = 3.77e-009           DTOX       = 5.087e-010          EPSROX     = 3.9
+WINT       = 1e-009              LINT       = 6.25e-009           LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = 1.52693e-08         DWC        = 0                   XL         = '-0.055e-6+dxl_18'
+XW         = '0+dxw_18'          XPART      = 1                   TOXREF     = 3e-009
+DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'    K1         = 0.3173
+K2         = 0.018357593         LK2        = 6.8982417e-010      WK2        = 9.8861485e-009
+PK2        = -1.8723068e-015     K3         = -1.316              K3B        = 1.9
+W0         = 0                   DVT0       = 0.17                DVT1       = 0.2
+DVT2       = -0.15               DVT0W      = 0                   DVT1W      = 0
+DVT2W      = 0                   DSUB       = 0.4141              MINV       = 0
+VOFFL      = 0                   DVTP0      = 2e-006              DVTP1      = 3.58
+LPE0       = 4e-008              LPEB       = 1.4e-007            XJ         = 1.2e-007
+NGATE      = 9.275e+019          NDEP       = 3.5e+017            NSD        = 1e+020
+PHIN       = 0                   CDSC       = 0                   CDSCB      = 0
+CDSCD      = 0                   CIT        = 0                   VOFF       = -0.11287427
+LVOFF      = -2.8028505e-009     WVOFF      = -6.4806052e-009     PVOFF      = -2.9348409e-016
+NFACTOR    = 1.2425929           LNFACTOR   = -1.0279149e-007     WNFACTOR   = -1.4199229e-007
+PNFACTOR   = 1.1534908e-013      ETA0       = 0.03                ETAB       = -0.071
+U0         = '161.04573+du0p_18' LU0        = -2.0187637e-005     WU0        = -1.7308617e-005
+PU0        = 8.1916231e-012      UA         = 1.6887814e-009      LUA        = -5.1552199e-016
+WUA        = -7.7822247e-016     PUA        = 2.6232254e-022      UB         = 1.3449619e-018
+LUB        = 4.8087088e-026      WUB        = 1.3396767e-025      PUB        = -5.2549099e-032
+UC         = -2.6694676e-011     LUC        = 2.2638246e-017      WUC        = 2.9669629e-017
+PUC        = -1.6382685e-023     VSAT       = '113938.42+dvsatp_18'
+LVSAT      = -5.2124354e-005     WVSAT      = -7.9402324e-005     PVSAT      = 4.680767e-011
+A0         = 1.1817397           LA0        = 1.4053325e-007      WA0        = 4.1394277e-007
+PA0        = -1.3527885e-013     AGS        = 0.54611948          LAGS       = 2.7230467e-007
+WAGS       = 1.1344744e-007      PAGS       = -9.4071153e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.083719296        LKETA      = -8.5088648e-009     WKETA      = 1.0637675e-008
+PKETA      = 3.7446136e-016      DWG        = 0                   DWB        = 0
+PCLM       = 16.832411           LPCLM      = -1.9727421e-006     WPCLM      = -5.1747948e-006
+PPCLM      = 3.3701522e-013      PDIBLC1    = 0                   PDIBLC2    = -0.0021568519
+LPDIBLC2   = 2.639376e-009       WPDIBLC2   = 5.8164446e-009      PPDIBLC2   = -2.0103239e-015
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.20862676
+LKT1       = -4.069575e-008      WKT1       = -8.497167e-008      PKT1       = 2.7148449e-014
+KT1L       = 0                   KT2        = -0.03924            UTE        = -1.1059292
+LUTE       = 8.1684513e-008      WUTE       = -1.2540744e-007     PUTE       = 2.1454576e-014
+UA1        = 3.2044499e-009      LUA1       = -2.0284562e-016     WUA1       = -4.1792935e-016
+PUA1       = 1.4165967e-022      UB1        = -6.341132e-018      LUB1       = 8.6078325e-025
+WUB1       = 9.1729211e-025      PUB1       = -2.8710889e-031     UC1        = -6.896e-012
+PRT        = 0                   AT         = 161327              WAT        = -0.034543366
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.15 PMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = '5.4e-007-dxw_18'   WMAX       = '9e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_18'
+TOXM       = 3.77e-009           DTOX       = 5.087e-010          EPSROX     = 3.9
+WINT       = 1e-009              LINT       = 6.25e-009           LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = 1.52693e-08         DWC        = 0                   XL         = '-0.055e-6+dxl_18'
+XW         = '0+dxw_18'          XPART      = 1                   TOXREF     = 3e-009
+DLCIG      = 2.5e-009            VTH0       = '-0.345263+dvthp_18'
+LVTH0      = '1.6815277e-009+dlvthp_18'
+WVTH0      = '1.2361573e-008+dwvthp_18'
+PVTH0      = -3.9495226e-015     K1         = 0.3173              K2         = 0.0047278706
+LK2        = 5.0445203e-009      WK2        = 1.1205255e-008      PK2        = -2.2937612e-015
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11691506         LVOFF      = -1.5118173e-009
+WVOFF      = 1.9510653e-010      PVOFF      = -2.426374e-015      NFACTOR    = 0.26706631
+LNFACTOR   = 2.0888924e-007      WNFACTOR   = 6.157643e-007       PNFACTOR   = -1.2675415e-013
+ETA0       = 0.069661667         LETA0      = -1.2671903e-008     WETA0      = -2.1337977e-008
+PETA0      = 6.8174835e-015      ETAB       = -0.071              U0         = '111.5433+du0p_18'
+LU0        = -4.3716128e-006     WU0        = 5.6747144e-006      PU0        = 8.4844859e-013
+UA         = -3.2848224e-011     LUA        = 3.4538663e-017      WUA        = 1.1484742e-016
+PUA        = -2.3013291e-023     UB         = 1.7012436e-018      LUB        = -6.5744925e-026
+WUB        = 3.3813645e-026      PUB        = -2.0549888e-032     UC         = 1.2042718e-010
+LUC        = -2.4367186e-017     WUC        = -4.9562552e-017     PUC        = 8.9319972e-024
+VSAT       = '99847.819+dvsatp_18'
+LVSAT      = 0.004449823         WVSAT      = 0.0075791333        PVSAT      = -2.4000945e-009
+A0         = 3.9320272           LA0        = -7.3818363e-007     WA0        = -1.6130969e-006
+PA0        = 5.1236032e-013      AGS        = 2.311494            LAGS       = -2.9173247e-007
+WAGS       = -3.245323e-007      PAGS       = 4.5863375e-014      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.13645747         LKETA      = 8.3409813e-009      WKETA      = 4.202576e-009
+PKETA      = 2.4304754e-015      DWG        = 0                   DWB        = 0
+PCLM       = 15.301841           LPCLM      = -1.483725e-006      WPCLM      = -6.4258829e-006
+PPCLM      = 7.3673786e-013      PDIBLC1    = 0                   PDIBLC2    = 0.01138418
+LPDIBLC2   = -1.6869837e-009     WPDIBLC2   = -2.3065216e-009     PPDIBLC2   = 5.8496379e-016
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.27482405
+LKT1       = -1.9545716e-008     WKT1       = -2.7575817e-008     PKT1       = 8.8104734e-015
+KT1L       = 0                   KT2        = -0.03924            UTE        = -1.0931643
+LUTE       = 7.7606115e-008      WUTE       = 8.1514193e-008      PUTE       = -4.4656887e-014
+UA1        = 1.8417846e-009      LUA1       = 2.3252596e-016      WUA1       = 1.1787048e-015
+PUA1       = -3.6846493e-022     UB1        = -2.8565222e-018     LUB1       = -2.5254959e-025
+WUB1       = -1.4256487e-024     PUB1       = 4.614607e-031       UC1        = -6.896e-012
+PRT        = 0                   AT         = 160292.11           LAT        = 0.00033064596
+WAT        = -0.0021180093       PAT        = -1.0359901e-008     JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+TTDIOMOD      = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_18.16 PMOS	(	LEVEL      = 54                  LMIN       = '9e-006-dxl_18'
+LMAX       = 0.000900001         WMIN       = 3.96e-007           WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.020117361         WK2        = 3.1648597e-009
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.11745996         WVOFF      = -7.3218662e-010
+NFACTOR    = 0.11172297          WNFACTOR   = 4.0037978e-008      ETA0       = 0.03
+ETAB       = -0.071              U0         = '132.70389+du0p_18' WU0        = -4.4308036e-006
+UA         = 1.0083919e-009      WUA        = -2.9050262e-016     UB         = 1.3397291e-018
+WUB        = 6.8169606e-027      UC         = 8.2e-012            VSAT       = '113850+dvsatp_18'
+A0         = 1.9861645           WA0        = 3.3198642e-008      AGS        = 0.58123509
+WAGS       = 9.572155e-009       A1         = 0                   A2         = 0.99
+B0         = 0                   B1         = 0                   KETA       = -0.071383333
+WKETA      = 1.2365033e-008      DWG        = 0                   DWB        = 0
+PCLM       = 2.1445833           WPCLM      = -3.0912583e-007     PDIBLC1    = 0
+PDIBLC2    = -0.00017887263      WPDIBLC2   = 6.3423347e-010      PDIBLCB    = 0
+DROUT      = 0.4800472           PVAG       = 0                   DELTA      = 0.01
+PSCBE1     = 4e+008              PSCBE2     = 1e-006              FPROUT     = 0
+PDITS      = 0.06                PDITSD     = 0.46                PDITSL     = 0
+RSH        = 10.45                RDSW       = 200                 RSW        = '185+drdswp_18'
+RDW        = '185+drdswp_18'     PRWG       = 0                   PRWB       = 0
+WR         = 1                   ALPHA0     = 8.242e-007          ALPHA1     = 2.999163
+BETA0      = 20.74914            AGIDL      = 1.488e-008          BGIDL      = 2.18e+009
+CGIDL      = 0.636               EGIDL      = 0.09287             AIGBACC    = 0.43
+BIGBACC    = 0.054               CIGBACC    = 0.075               NIGBACC    = 1
+AIGBINV    = 0.35                BIGBINV    = 0.03                CIGBINV    = 0.006
+EIGBINV    = 1.1                 NIGBINV    = 3                   AIGC       = 0.43
+BIGC       = 0.054               CIGC       = 0.075               AIGSD      = 0.43
+BIGSD      = 0.054               CIGSD      = 0.075               NIGC       = 1
+POXEDGE    = 1                   PIGCD      = 1                   NTOX       = 1
+XRCRG1     = 12                  XRCRG2     = 1                   CGSO       = 'cgop_18'
+CGDO       = 'cgop_18'           CGBO       = 0                   CGDL       = 'cglp_18'
+CGSL       = 'cglp_18'           CLC        = 1e-007              CLE        = 0.6
+CF         = 'cfp_18'            CKAPPAS    = 0.6                 CKAPPAD    = 0.6
+ACDE       = 1.404               MOIN       = 12.6                NOFF       = 1.228
+VOFFCV     = -0.0549             KT1        = -0.264              KT1L       = 0
+KT2        = -0.03924            UTE        = -0.62956461         WUTE       = -3.0689424e-007
+UA1        = 5.1459136e-009      WUA1       = -1.3699103e-015     UB1        = -5.9748526e-018
+WUB1       = 1.2175583e-024      UC1        = -6.896e-012         PRT        = 0
+AT         = 97120               JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_18'
+TTDIOMOD      = 1
+LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.17 PMOS	(	LEVEL      = 54                  LMIN       = '1.107e-006-dxl_18'
+LMAX       = '9e-006-dxl_18'     WMIN       = 3.96e-007           WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.019110961         LK2        = 8.9896649e-009
+WK2        = 3.2811785e-009      PK2        = -1.039017e-015      K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.11718915         LVOFF      = -2.4189649e-009     WVOFF      = -8.2861484e-010
+PVOFF      = 8.6134513e-016      NFACTOR    = -0.00098363664      LNFACTOR   = 1.0067517e-006
+WNFACTOR   = 4.5310939e-008      PNFACTOR   = -4.7100721e-014     ETA0       = 0.03
+ETAB       = -0.071              U0         = '129.89645+du0p_18' LU0        = 2.5077456e-005
+WU0        = -3.3678443e-006     PU0        = -9.4948841e-012     UA         = 9.1361272e-010
+LUA        = 8.4661497e-016      WUA        = -2.5010109e-016     PUA        = -3.6088664e-022
+UB         = 1.392675e-018       LUB        = -4.7293985e-025     WUB        = -1.7514009e-026
+PUB        = 2.1733639e-031      UC         = 7.966966e-012       LUC        = 2.0815764e-018
+WUC        = -2.7141037e-019     PUC        = 2.4243731e-024      VSAT       = '113850+dvsatp_18'
+A0         = 2.0050701           LA0        = -1.6887447e-007     WA0        = 3.5289278e-008
+PA0        = -1.86746e-014       AGS        = 0.54549677          LAGS       = 3.1923259e-007
+WAGS       = 1.4382439e-008      PAGS       = -4.2967857e-014     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.07251375         LKETA      = 1.0097443e-008      WKETA      = 1.3993496e-008
+PKETA      = -1.4546239e-014     DWG        = 0                   DWB        = 0
+PCLM       = 2.3090424           LPCLM      = -1.4690309e-006     WPCLM      = -6.4063421e-007
+PPCLM      = 2.9611986e-012      PDIBLC1    = 0                   PDIBLC2    = -0.00093174097
+LPDIBLC2   = 6.7249965e-009      WPDIBLC2   = 6.8993735e-010      PPDIBLC2   = -4.9757487e-016
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.25833694
+LKT1       = -5.0585247e-008     KT1L       = 0                   KT2        = -0.03924
+UTE        = -0.65416463         LUTE       = 2.1973969e-007      WUTE       = -3.116055e-007
+PUTE       = 4.2083307e-014      UA1        = 5.0047769e-009      LUA1       = 1.2607036e-015
+WUA1       = -1.3493376e-015     PUA1       = -1.8376575e-022     UB1        = -5.6902973e-018
+LUB1       = -2.5417899e-024     WUB1       = 1.1515719e-024      PUB1       = 5.8942398e-031
+UC1        = -6.896e-012         PRT        = 0                   AT         = 97120
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  WVTH0      = '0+dwvthp_18'       LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.18 PMOS	(	LEVEL      = 54                  LMIN       = '6.57e-007-dxl_18'
+LMAX       = '1.107e-006-dxl_18' WMIN       = 3.96e-007           WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TEMPMOD    = 0                   TNOM       = 25
+TOXE       = 'toxp_18'           TOXM       = 3.77e-009           DTOX       = 5.087e-010
+EPSROX     = 3.9                 WINT       = 1e-009              LINT       = 6.25e-009
+LL         = 0                   WL         = 0                   LLN        = 1
+WLN        = 1                   LW         = 0                   WW         = 0
+LWN        = 1                   WWN        = 1                   LWL        = 0
+WWL        = 0                   LLC        = 0                   WLC        = 0
+LWC        = 0                   WWC        = 0                   LWLC       = 0
+WWLC       = 0                   DLC        = 1.52693e-08         DWC        = 0
+XL         = '-0.055e-6+dxl_18'  XW         = '0+dxw_18'          XPART      = 1
+TOXREF     = 3e-009              DLCIG      = 2.5e-009            VTH0       = '-0.34+dvthp_18'
+K1         = 0.3173              K2         = 0.027400597         LK2        = 3.7258856e-010
+WK2        = 2.4744787e-009      PK2        = -2.0045265e-016     K3         = -1.316
+K3B        = 1.9                 W0         = 0                   DVT0       = 0.17
+DVT1       = 0.2                 DVT2       = -0.15               DVT0W      = 0
+DVT1W      = 0                   DVT2W      = 0                   DSUB       = 0.4141
+MINV       = 0                   VOFFL      = 0                   DVTP0      = 2e-006
+DVTP1      = 3.58                LPE0       = 4e-008              LPEB       = 1.4e-007
+XJ         = 1.2e-007            NGATE      = 9.275e+019          NDEP       = 3.5e+017
+NSD        = 1e+020              PHIN       = 0                   CDSC       = 0
+CDSCB      = 0                   CDSCD      = 0                   CIT        = 0
+VOFF       = -0.086358033        LVOFF      = -3.4467914e-008     WVOFF      = -1.0027453e-008
+PVOFF      = 1.0423538e-014      NFACTOR    = 1.2711942           LNFACTOR   = -3.1567708e-007
+WNFACTOR   = -3.0468031e-007     PNFACTOR   = 3.1671518e-013      ETA0       = 0.03
+ETAB       = -0.071              U0         = '196.17652+du0p_18' LU0        = -4.3820672e-005
+WU0        = -2.7903907e-005     PU0        = 1.6010353e-011      UA         = 3.6702287e-009
+LUA        = -2.0188873e-015     WUA        = -1.3440437e-015     PUA        = 7.7626671e-022
+UB         = -2.4675158e-019     LUB        = 1.2312441e-024      WUB        = 6.7651266e-025
+PUB        = -5.0410433e-031     UC         = -6.9186389e-012     LUC        = 1.7555163e-017
+WUC        = 1.0159936e-017      PUC        = -8.4190112e-024     VSAT       = '113850+dvsatp_18'
+A0         = 2.5024727           LA0        = -6.8592448e-007     WA0        = -2.5887612e-007
+PA0        = 2.8711033e-013      AGS        = 0.79569961          LAGS       = 5.914673e-008
+WAGS       = -8.0772915e-008     PAGS       = 5.5946133e-014      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.043936           LKETA      = -1.9609128e-008     DWG        = 0
+DWB        = 0                   PCLM       = -4.1380236          LPCLM      = 5.2326943e-006
+WPCLM      = 4.9655913e-006      PPCLM      = -2.8664728e-012     PDIBLC1    = 0
+PDIBLC2    = 0.0074740063        LPDIBLC2   = -2.0127778e-009     WPDIBLC2   = -1.4383947e-009
+PPDIBLC2   = 1.7148263e-015      PDIBLCB    = 0                   DROUT      = 0.4800472
+PVAG       = 0                   DELTA      = 0.01                PSCBE1     = 4e+008
+PSCBE2     = 1e-006              FPROUT     = 0                   PDITS      = 0.06
+PDITSD     = 0.46                PDITSL     = 0                   RSH        = 10.45
+RDSW       = 200                 RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'
+PRWG       = 0                   PRWB       = 0                   WR         = 1
+ALPHA0     = 8.242e-007          ALPHA1     = 2.999163            BETA0      = 20.74914
+AGIDL      = 1.488e-008          BGIDL      = 2.18e+009           CGIDL      = 0.636
+EGIDL      = 0.09287             AIGBACC    = 0.43                BIGBACC    = 0.054
+CIGBACC    = 0.075               NIGBACC    = 1                   AIGBINV    = 0.35
+BIGBINV    = 0.03                CIGBINV    = 0.006               EIGBINV    = 1.1
+NIGBINV    = 3                   AIGC       = 0.43                BIGC       = 0.054
+CIGC       = 0.075               AIGSD      = 0.43                BIGSD      = 0.054
+CIGSD      = 0.075               NIGC       = 1                   POXEDGE    = 1
+PIGCD      = 1                   NTOX       = 1                   XRCRG1     = 12
+XRCRG2     = 1                   CGSO       = 'cgop_18'           CGDO       = 'cgop_18'
+CGBO       = 0                   CGDL       = 'cglp_18'           CGSL       = 'cglp_18'
+CLC        = 1e-007              CLE        = 0.6                 CF         = 'cfp_18'
+CKAPPAS    = 0.6                 CKAPPAD    = 0.6                 ACDE       = 1.404
+MOIN       = 12.6                NOFF       = 1.228               VOFFCV     = -0.0549
+KT1        = -0.25067            LKT1       = -5.8555035e-008     KT1L       = 0
+KT2        = -0.03924            UTE        = 0.46117778          LUTE       = -9.3965874e-007
+WUTE       = -6.2629024e-007     PUTE       = 3.6919809e-013      UA1        = 1.1048043e-008
+LUA1       = -5.0212713e-015     WUA1       = -3.5253381e-015     PUA1       = 2.0781868e-021
+UB1        = -1.3446622e-017     LUB1       = 5.52091e-024        WUB1       = 3.9699621e-024
+PUB1       = -2.3402927e-030     UC1        = -6.896e-012         PRT        = 0
+AT         = 97120               JSS        = 1.6E-07             JSD        = 1.6E-07
+JSWS       = 1E-13               JSWD       = 1E-13               JSWGS      = 2E-13
+JSWGD      = 2E-13               NJS        = 1                   NJD        = 1
+IJTHSFWD   = 0.01                IJTHDFWD   = 0.01                IJTHSREV   = 0.01
+IJTHDREV   = 0.01                BVS        = 10                  BVD        = 10
+XJBVS      = 1                   XJBVD      = 1                   PBS        = 0.8
+PBD        = 0.8                 CJS        = 'cjp_18'            CJD        = 'cjp_18'
+MJS        = 0.36                MJD        = 0.36                PBSWD      = 0.48
+PBSWS      = 0.48                CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'
+MJSWS      = 0.04                MJSWD      = 0.04                PBSWGS     = 1
+PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'
+MJSWGS     = 0.85                MJSWGD     = 0.85                TPB        = 1.90E-03
+TCJ        = 9.45E-04            TPBSW      = 1E-03               TCJSW      = 2.7E-04
+TPBSWG     = 1E-03               TCJSWG     = 1E-03               XTIS       = 3
+XTID       = 3                   JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007
+NJTSSWG    = 22                  XTSSWGS    = 0.12                XTSSWGD    = 0.12
+TNJTSSWG   = 0                   VTSSWGS    = 10                  VTSSWGD    = 10
+DMCG       = 1.415e-7            DMCI       = 1.415e-7            DMDG       = 0
+DMCGT      = 0                   DWJ        = 0                   XGW        = 0
+XGL        = 0                   RSHG       = 1                   GBMIN      = 1e-012
+RBPB       = 50                  RBPD       = 50                  RBPS       = 50
+RBDB       = 50                  RBSB       = 50                  WVTH0      = '0+dwvthp_18'
+TTDIOMOD      = 1
+LVTH0      = '0+dlvthp_18'       )

.MODEL pch_18.19 PMOS	(	LEVEL      = 54                  LMIN       = '3.87e-007-dxl_18'
+LMAX       = '6.57e-007-dxl_18'  WMIN       = 3.96e-007           WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_18'
+TOXM       = 3.77e-009           DTOX       = 5.087e-010          EPSROX     = 3.9
+WINT       = 1e-009              LINT       = 6.25e-009           LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = 1.52693e-08         DWC        = 0                   XL         = '-0.055e-6+dxl_18'
+XW         = '0+dxw_18'          XPART      = 1                   TOXREF     = 3e-009
+DLCIG      = 2.5e-009            VTH0       = '-0.35618866+dvthp_18'
+LVTH0      = '9.5432135e-009+dlvthp_18'
+WVTH0      = '8.7094977e-009+dwvthp_18'
+PVTH0      = -5.1342489e-015     K1         = 0.3173              K2         = 0.02483353
+LK2        = 1.8858746e-009      WK2        = 6.4020941e-009      PK2        = -2.515782e-015
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.15727907         LVOFF      = 7.3400392e-009
+WVOFF      = 1.7409182e-008      PVOFF      = -5.7503588e-015     NFACTOR    = 0.55607431
+LNFACTOR   = 1.0588607e-007      WNFACTOR   = 2.2735469e-007      PNFACTOR   = 3.0805493e-015
+ETA0       = 0.03                ETAB       = -0.071              U0         = '132.47238+du0p_18'
+LU0        = -6.2670836e-006     WU0        = -1.9361581e-006     PU0        = 7.0236525e-013
+UA         = 2.2623588e-010      LUA        = 1.1346434e-017      WUA        = 8.626993e-018
+PUA        = -2.1132671e-023     UB         = 1.9578409e-018      LUB        = -6.8363135e-026
+WUB        = -1.9576122e-025     PUB        = 1.0101121e-032      UC         = 1.5716736e-011
+LUC        = 4.2116091e-018      WUC        = 6.8522893e-018      PUC        = -6.4691536e-024
+VSAT       = '113628.95+dvsatp_18'
+LVSAT      = 0.00013031089       WVSAT      = 8.7094977e-005      PVSAT      = -5.1342489e-011
+A0         = 1.0154912           LA0        = 1.9065112e-007      WA0        = 5.0338443e-007
+PA0        = -1.6224226e-013     AGS        = 0.73201676          LAGS       = 9.668777e-008
+WAGS       = 1.3434707e-008      PAGS       = 4.1073991e-016      A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.036749722        LKETA      = -2.3845439e-008     WKETA      = -1.4631956e-008
+PKETA      = 8.6255381e-015      DWG        = 0                   DWB        = 0
+PCLM       = 10.033396           LPCLM      = -3.1213575e-006     WPCLM      = -1.5169246e-006
+PPCLM      = 9.5497029e-013      PDIBLC1    = 0                   PDIBLC2    = 0.0038326715
+LPDIBLC2   = 1.3378907e-010      WPDIBLC2   = 2.594081e-009       PPDIBLC2   = -6.6231811e-016
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.34390255
+LKT1       = -3.594449e-009      WKT1       = -1.2193297e-008     PKT1       = 7.1879484e-015
+KT1L       = 0                   KT2        = -0.03924            UTE        = -1.3390286
+LUTE       = 1.2156291e-007      UA1        = 2.4276296e-009      LUA1       = 6.0462313e-017
+UB1        = -4.6361281e-018     LUB1       = 3.2712361e-025      UC1        = -6.896e-012
+PRT        = 0                   AT         = 97120               JSS        = 1.6E-07
+JSD        = 1.6E-07             JSWS       = 1E-13               JSWD       = 1E-13
+JSWGS      = 2E-13               JSWGD      = 2E-13               NJS        = 1
+NJD        = 1                   IJTHSFWD   = 0.01                IJTHDFWD   = 0.01
+IJTHSREV   = 0.01                IJTHDREV   = 0.01                BVS        = 10
+BVD        = 10                  XJBVS      = 1                   XJBVD      = 1
+PBS        = 0.8                 PBD        = 0.8                 CJS        = 'cjp_18'
+CJD        = 'cjp_18'            MJS        = 0.36                MJD        = 0.36
+PBSWD      = 0.48                PBSWS      = 0.48                CJSWS      = 'cjswp_18'
+CJSWD      = 'cjswp_18'          MJSWS      = 0.04                MJSWD      = 0.04
+PBSWGS     = 1                   PBSWGD     = 1                   CJSWGS     = 'cjswgp_18'
+CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85                MJSWGD     = 0.85
+TPB        = 1.90E-03            TCJ        = 9.45E-04            TPBSW      = 1E-03
+TCJSW      = 2.7E-04             TPBSWG     = 1E-03               TCJSWG     = 1E-03
+XTIS       = 3                   XTID       = 3                   JTSSWGS    = 2.4e-007
+JTSSWGD    = 2.4e-007            NJTSSWG    = 22                  XTSSWGS    = 0.12
+XTSSWGD    = 0.12                TNJTSSWG   = 0                   VTSSWGS    = 10
+VTSSWGD    = 10                  DMCG       = 1.415e-7            DMCI       = 1.415e-7
+DMDG       = 0                   DMCGT      = 0                   DWJ        = 0
+XGW        = 0                   XGL        = 0                   RSHG       = 1
+GBMIN      = 1e-012              RBPB       = 50                  RBPD       = 50
+TTDIOMOD      = 1
+RBPS       = 50                  RBDB       = 50                  RBSB       = 50                  )

.MODEL pch_18.20 PMOS	(	LEVEL      = 54                  LMIN       = 2e-007
+LMAX       = '3.87e-007-dxl_18'  WMIN       = 3.96e-007           WMAX       = '5.4e-007-dxw_18'
+VERSION    = 4.4                 RGEOMOD    = 1                   BINUNIT    = 2
+PARAMCHK   = 1                   MOBMOD     = 0                   CAPMOD     = 2
+IGCMOD     = 0                   IGBMOD     = 0                   GEOMOD     = 0
+DIOMOD     = 1                   RDSMOD     = 1                   RBODYMOD   = 0
+RGATEMOD   = 0                   PERMOD     = 1                   ACNQSMOD   = 0
+TRNQSMOD   = 0                   TNOM       = 25                  TOXE       = 'toxp_18'
+TOXM       = 3.77e-009           DTOX       = 5.087e-010          EPSROX     = 3.9
+WINT       = 1e-009              LINT       = 6.25e-009           LL         = 0
+WL         = 0                   LLN        = 1                   WLN        = 1
+LW         = 0                   WW         = 0                   LWN        = 1
+WWN        = 1                   LWL        = 0                   WWL        = 0
+LLC        = 0                   WLC        = 0                   LWC        = 0
+WWC        = 0                   LWLC       = 0                   WWLC       = 0
+DLC        = 1.52693e-08         DWC        = 0                   XL         = '-0.055e-6+dxl_18'
+XW         = '0+dxw_18'          XPART      = 1                   TOXREF     = 3e-009
+DLCIG      = 2.5e-009            VTH0       = '-0.2989121+dvthp_18'
+LVTH0      = '-8.7566469e-009+dlvthp_18'
+WVTH0      = '-1.2575211e-008+dwvthp_18'
+PVTH0      = 1.6662154e-015      K1         = 0.3173              K2         = 0.030230281
+LK2        = 1.616128e-010       WK2        = -2.5150421e-009     PK2        = 3.3324308e-016
+K3         = -1.316              K3B        = 1.9                 W0         = 0
+DVT0       = 0.17                DVT1       = 0.2                 DVT2       = -0.15
+DVT0W      = 0                   DVT1W      = 0                   DVT2W      = 0
+DSUB       = 0.4141              MINV       = 0                   VOFFL      = 0
+DVTP0      = 2e-006              DVTP1      = 3.58                LPE0       = 4e-008
+LPEB       = 1.4e-007            XJ         = 1.2e-007            NGATE      = 9.275e+019
+NDEP       = 3.5e+017            NSD        = 1e+020              PHIN       = 0
+CDSC       = 0                   CDSCB      = 0                   CDSCD      = 0
+CIT        = 0                   VOFF       = -0.12088629         LVOFF      = -4.2874555e-009
+WVOFF      = 2.331629e-009       PVOFF      = -9.3308062e-016     NFACTOR    = 0.87416132
+LNFACTOR   = 4.2572711e-009      WNFACTOR   = 2.8914719e-007      PNFACTOR   = -1.6662154e-014
+ETA0       = 0.03                ETAB       = -0.071              U0         = '121.25852+du0p_18'
+LU0        = -2.6842537e-006     WU0        = 4.47929e-007        PU0        = -5.9350593e-014
+UA         = 3.6327939e-010      LUA        = -3.2438966e-017     WUA        = -9.8269234e-017
+PUA        = 1.3020674e-023      UB         = 2.2853812e-018      LUB        = -1.7301226e-025
+WUB        = -2.8045235e-025     PUB        = 3.7159936e-032      UC         = 7.0844151e-011
+LUC        = -1.34016e-017       WUC        = -2.2886883e-017     PUC        = 3.032512e-024
+VSAT       = '114266.1+dvsatp_18'
+LVSAT      = -7.3260277e-005     WVSAT      = -0.00017790282      PVSAT      = 3.3324308e-011
+A0         = 0.33898214          LA0        = 4.0679577e-007      WA0        = 3.1996137e-007
+PA0        = -1.036386e-013      AGS        = 1.6615261           LAGS       = -2.0029045e-007
+WAGS       = 2.5150421e-008      PAGS       = -3.3324308e-015     A1         = 0
+A2         = 0.99                B0         = 0                   B1         = 0
+KETA       = -0.1679143          LKETA      = 1.8061645e-008      WKETA      = 2.1126354e-008
+PKETA      = -2.7992419e-015     DWG        = 0                   DWB        = 0
+PCLM       = -1.6775746          LPCLM      = 6.202976e-007       WPCLM      = 2.7090428e-006
+PPCLM      = -3.9522629e-013     PDIBLC1    = 0                   PDIBLC2    = 0.0054420862
+LPDIBLC2   = -3.8041893e-010     WPDIBLC2   = 8.9032491e-010      PPDIBLC2   = -1.1796805e-016
+PDIBLCB    = 0                   DROUT      = 0.4800472           PVAG       = 0
+DELTA      = 0.01                PSCBE1     = 4e+008              PSCBE2     = 1e-006
+FPROUT     = 0                   PDITS      = 0.06                PDITSD     = 0.46
+PDITSL     = 0                   RSH        = 10.45                RDSW       = 200
+RSW        = '185+drdswp_18'     RDW        = '185+drdswp_18'     PRWG       = 0
+PRWB       = 0                   WR         = 1                   ALPHA0     = 8.242e-007
+ALPHA1     = 2.999163            BETA0      = 20.74914            AGIDL      = 1.488e-008
+BGIDL      = 2.18e+009           CGIDL      = 0.636               EGIDL      = 0.09287
+AIGBACC    = 0.43                BIGBACC    = 0.054               CIGBACC    = 0.075
+NIGBACC    = 1                   AIGBINV    = 0.35                BIGBINV    = 0.03
+CIGBINV    = 0.006               EIGBINV    = 1.1                 NIGBINV    = 3
+AIGC       = 0.43                BIGC       = 0.054               CIGC       = 0.075
+AIGSD      = 0.43                BIGSD      = 0.054               CIGSD      = 0.075
+NIGC       = 1                   POXEDGE    = 1                   PIGCD      = 1
+NTOX       = 1                   XRCRG1     = 12                  XRCRG2     = 1
+CGSO       = 'cgop_18'           CGDO       = 'cgop_18'           CGBO       = 0
+CGDL       = 'cglp_18'           CGSL       = 'cglp_18'           CLC        = 1e-007
+CLE        = 0.6                 CF         = 'cfp_18'            CKAPPAS    = 0.6
+CKAPPAD    = 0.6                 ACDE       = 1.404               MOIN       = 12.6
+NOFF       = 1.228               VOFFCV     = -0.0549             KT1        = -0.35880381
+LKT1       = 1.1665048e-009      WKT1       = 1.7605295e-008      PKT1       = -2.3327016e-015
+KT1L       = 0                   KT2        = -0.03924            UTE        = -0.94165094
+LUTE       = -5.399251e-009      UA1        = 4.0326856e-009      LUA1       = -4.523531e-016
+UB1        = -5.5064268e-018     LUB1       = 6.0518405e-025      UC1        = -6.896e-012
+PRT        = 0                   AT         = 156355.29           LAT        = -0.018925676
+JSS        = 1.6E-07             JSD        = 1.6E-07             JSWS       = 1E-13
+JSWD       = 1E-13               JSWGS      = 2E-13               JSWGD      = 2E-13
+NJS        = 1                   NJD        = 1                   IJTHSFWD   = 0.01
+IJTHDFWD   = 0.01                IJTHSREV   = 0.01                IJTHDREV   = 0.01
+BVS        = 10                  BVD        = 10                  XJBVS      = 1
+XJBVD      = 1                   PBS        = 0.8                 PBD        = 0.8
+CJS        = 'cjp_18'            CJD        = 'cjp_18'            MJS        = 0.36
+MJD        = 0.36                PBSWD      = 0.48                PBSWS      = 0.48
+CJSWS      = 'cjswp_18'          CJSWD      = 'cjswp_18'          MJSWS      = 0.04
+MJSWD      = 0.04                PBSWGS     = 1                   PBSWGD     = 1
+CJSWGS     = 'cjswgp_18'         CJSWGD     = 'cjswgp_18'         MJSWGS     = 0.85
+MJSWGD     = 0.85                TPB        = 1.90E-03            TCJ        = 9.45E-04
+TPBSW      = 1E-03               TCJSW      = 2.7E-04             TPBSWG     = 1E-03
+TCJSWG     = 1E-03               XTIS       = 3                   XTID       = 3
+JTSSWGS    = 2.4e-007            JTSSWGD    = 2.4e-007            NJTSSWG    = 22
+XTSSWGS    = 0.12                XTSSWGD    = 0.12                TNJTSSWG   = 0
+VTSSWGS    = 10                  VTSSWGD    = 10                  DMCG       = 1.415e-7
+DMCI       = 1.415e-7            DMDG       = 0                   DMCGT      = 0
+DWJ        = 0                   XGW        = 0                   XGL        = 0
+RSHG       = 1                   GBMIN      = 1e-012              RBPB       = 50
+RBPD       = 50                  RBPS       = 50                  RBDB       = 50
+TTDIOMOD      = 1
+RBSB       = 50                  )

.ENDL MOS_18

*
*
*
***************************************************************
*                                                             *
*  Vertical BIPOLAR MODELS for 1.05V device process            *
*                                                             *
***************************************************************
*
******************************    LIBRARY OF TYPICAL CASE    ******************************
.LIB TT_BIP
.param
+bfa    = 1        isa    = 1        nfa    = 1        rba    = 1        rea    = 1
+rca    = 1        rbma   = 1        cjea   = 1        cjca   = 1
.lib 'models.sp' BIP
.ENDL TT_BIP

******************************  LIBRARY OF SS CORNER CASE  ******************************
.LIB SS_BIP
.param
+bfa    = 0.85     isa    = 0.7      nfa    = 1.0025   rba    = 1.2      rea    = 1.2
+rca    = 1.2      rbma   = 1.2      cjea   = 1.07     cjca   = 1.07
.lib 'models.sp' BIP
.ENDL SS_BIP

******************************  LIBRARY OF FF CORNER CASE  ******************************
.LIB FF_BIP
.param
+bfa    = 1.15     isa    = 1.3      nfa    = 0.9975   rba    = 0.8      rea    = 0.8
+rca    = 0.8      rbma   = 0.8      cjea   = 0.93     cjca   = 0.93
.lib 'models.sp' BIP
.ENDL FF_BIP

*******************************************************************************************
*                                                                                         *
*                   MODELS OF VERTICAL P+/NW/SUB PNP BIPOLAR                              *
*                                                                                         *
*******************************************************************************************
.LIB BIP
*
***************************************************************
*                                                             *
*        MODEL OF P+/NW/PSUB VERTICAL PNP10X10 BIPOLAR        *
*                                                             *
***************************************************************

*
.MODEL PNP10 PNP (                                             LEVEL  = 1
+IS       = '5.601e-018*isa'    BF       = '0.8087*bfa'        NF       = '1.005*nfa'
+VAF      = 696.2               IKF      = 0.005492            ISE      = '5.601e-018*isa'
+NE       = 1.223               BR       = 0.004679            NR       = 1.008
+VAR      = 61.62               IKR      = 0.00163             ISC      = '5.601e-018*isa'
+NC       = 1                   RB       = '49.4*rba'          IRB      = 0.001
+RBM      = '0.1*rbma'          RE       = '3.058*rea'         RC       = '5.776*rca'
+NKF      = 0.5007              SUBS     = 1                   TREF     = 25
+XTB      = 0                   XTI      = 3                   EG       = 1.18
+TLEV     = 1                   TLEVC    = 1                   TBF1     = 0.004306
+TBR1     = -0.0001699          TIKF1    = -0.003601           TIS1     = 5.6
+TNF1     = 2.947e-005          TNR1     = 0.00018             TRB1     = 0.002517
+TRC1     = 0.001419            TRE1     = 0.00025             CJE      = '8.657E-14*cjea'
+VJE      = 0.8                 MJE      = 0.35                CJC      = '7.936E-14*cjca'
+VJC      = 0.8                 MJC      = 0.45                FC       = 0
+CTC      = 1.64E-03            CTE      = 8.74E-04            TVJC     = 2.80E-03
+TVJE     = 1.90E-03            )
*
***************************************************************
*                                                             *
*       MODEL OF P+/NW/PSUB VERTICAL PNP5X5 BIPOLAR           *
*                                                             *
***************************************************************
*
.MODEL PNP5 PNP (                                              LEVEL  = 1
+IS       = '1.718e-018*isa'    BF       = '0.8674*bfa'        NF       = '1.005*nfa'
+VAF      = 854.9               IKF      = 0.002873            ISE      = '1.718e-018*isa'
+NE       = 1.141               BR       = 0.002015            NR       = 1.006
+VAR      = 54.91               IKR      = 0.00163             ISC      = '1.718e-018*isa'
+NC       = 1.096               RB       = '73.03*rba'         IRB      = 0.001
+RBM      = '0.1*rbma'          RE       = '3.241*rea'         RC       = '6.065*rca'
+NKF      = 0.5043              SUBS     = 1                   TREF     = 25
+XTB      = 0                   XTI      = 3                   EG       = 1.18
+TLEV     = 1                   TLEVC    = 1                   TBF1     = 0.004464
+TBR1     = -6.13e-005          TIKF1    = -0.003161           TNF1     = 1.704e-005
+TNR1     = 0.00018             TRB1     = 0.002064            TRC1     = 0.001652
+TRE1     = 0.0001              CJE      = '2.216E-14*cjea'    VJE      = 0.8
+MJE      = 0.35                CJC      = '4.864E-14*cjca'    VJC      = 0.8
+MJC      = 0.45                FC       = 0                   CTC      = 1.64E-03
+CTE      = 8.74E-04            TVJC     = 2.80E-03            TVJE     = 1.90E-03
+)
*
***************************************************************
*                                                             *
*       MODEL OF P+/NW/PSUB VERTICAL PNP2X2 BIPOLAR           *
*                                                             *
***************************************************************
*
.MODEL PNP2 PNP (                                              LEVEL  = 1
+IS       = '3.192e-019*isa'    BF       = '0.969*bfa'         NF       = '1.005*nfa'
+VAF      = 500.1               IKF      = 0.0007542           ISE      = '3.192e-019*isa'
+NE       = 1.371               BR       = 0.0006354           NR       = 1.008
+VAR      = 41.49               IKR      = 0.00163             ISC      = '3.192e-019*isa'
+NC       = 1.13                RB       = '104.5*rba'         IRB      = 0.001
+RBM      = '0.1*rbma'          RE       = '5.43*rea'          RC       = '6.97*rca'
+NKF      = 0.4441              SUBS     = 1                   TREF     = 25
+XTB      = 0                   XTI      = 3                   EG       = 1.18
+TLEV     = 1                   TLEVC    = 1                   TBF1     = 0.004627
+TBR1     = -0.0003622          TIKF1    = -0.001376           TNF1     = 1.26e-006
+TNR1     = 0.00018             TRB1     = 0.001067            TRC1     = 0.001947
+TRE1     = 0.0001398           CJE      = '3.797E-15*cjea'    VJE      = 0.8
+MJE      = 0.35                CJC      = '3.278E-14*cjca'    VJC      = 0.8
+MJC      = 0.45                FC       = 0                   CTC      = 1.64E-03
+CTE      = 8.74E-04            TVJC     = 2.80E-03            TVJE     = 1.90E-03
+)
*
*
.ENDL BIP

***************************************************************
*                                                             *
*             1.05V Standard Vt Junction DIODE MODELS         *
*                                                             *
***************************************************************
***************** CORNER_LIB OF TYPICAL MODEL ****************************
.LIB TT_DIO
.param
+is_d= 1         jsw_d= 1         n_d= 1         rs_d= 1
+cj_d= 1         cjsw_d= 1
.lib 'models.sp' DIO
.ENDL TT_DIO
******************* CORNER_LIB OF SLOW MODEL *****************************
.LIB SS_DIO
.param
+is_d= 0.7         jsw_d= 0.5         n_d= 1.0025         rs_d= 1.2
+cj_d= 1.07        cjsw_d= 1.07
.lib 'models.sp' DIO
.ENDL SS_DIO
******************* CORNER_LIB OF FAST MODEL *****************************
.LIB FF_DIO
.param
+is_d= 1.3         jsw_d= 2         n_d= 0.9975         rs_d= 0.8
+cj_d= 0.93        cjsw_d= 0.93
.lib 'models.sp' DIO
.ENDL FF_DIO
**************************************************************************

***************************************************************
*                                                             *
*             1.05V Standard Vt Junction DIODE MODELS         *
*                                                             *
***************************************************************
*
.LIB DIO
*
***************************************************************
*                      MODEL OF N+/PW DIODE                   *
*                                                             *
***************************************************************

.MODEL NDIO D (                                          LEVEL  = 3
+ IS     = '1.9E-07*is_d'    IKR    = 1E10               RS     = '1.0E-10*rs_d'
+ N      = '1.04*n_d'        BV     = 10.8               IBV    = 0.03
+ JSW    = '4.5E-13*jsw_d'   CJ     = '9.17E-04*cj_d'    PJ     = 7.56E-4
+ MJ     = 0.25              FC     = 0                  CJSW   = '9.0E-11*cjsw_d'
+ AREA   = 3.1752E-8         MJSW   = 0.01               TLEVC  = 1
+ CTA    = 1.14E-03          CTP    = 3.57E-04           TRS    = 2.5E-3
+ TCV    = -6.50E-04         TLEV   = 1                  XTI    = 3
+ EG     = 1.17              PHP    = 0.7                PB     = 0.53
+ IK     = 1E20              TPB    = 1.50E-03           TREF   = 25
+ TPHP   = 1.90E-03          FCS    = 0                  )

***************************************************************
*                      MODEL OF P+/NW DIODE                   *
*                                                             *
***************************************************************

.MODEL PDIO D (                                          LEVEL  = 3
+ IS     = '1.50E-07*is_d'   IKR    = 1E10               RS     = '1.0E-10*rs_d'
+ N      = '1.04*n_d'        BV     = 10.5               IBV    = 0.03
+ JSW    = '7.0E-13*jsw_d'   CJ     = '9.57E-04*cj_d'    PJ     = 7.56E-4
+ MJ     = 0.35              FC     = 0                  CJSW   = '7.10E-11*cjsw_d'
+ AREA   = 3.1752E-8         MJSW   = 0.06               TLEVC  = 1
+ CTA    = 9.39E-04          CTP    = 6.00E-04           TRS    = 2.5E-3
+ TCV    = -7.5E-04          TLEV   = 1                  XTI    = 3
+ EG     = 1.17              PHP    = 0.4                PB     = 0.8
+ IK     = 1E20              TPB    = 1.90E-03           TREF   = 25
+ TPHP   = 1.60E-03          FCS    = 0                  )

***************************************************************
*                      MODEL OF NW/PSUB DIODE                 *
*                                                             *
***************************************************************

.MODEL NWDIO D (                                         LEVEL  = 3
+ IS     = '6.00E-07*is_d'   IKR    = 1E10               RS     = '4.8E-10*rs_d'
+ N      = '1.01*n_d'        BV     = 12.0               IBV    = 0.03
+ JSW    = '7.00E-13*jsw_d'  CJ     = '1.26E-04*cj_d'    PJ     = 7.56E-4
+ MJ     = 0.45              FC     = 0                  CJSW   = '8.33E-10*cjsw_d'
+ AREA   = 3.1752E-8         MJSW   = 0.36               TLEVC  = 1
+ CTA    = 2.8E-03           CTP    = 1.4E-03            TRS    = 6.0E-4
+ TCV    = -8.00E-04         TLEV   = 1                  XTI    = 3
+ EG     = 1.17              PHP    = 0.8                PB     = 0.75
+ IK     = 1E20              TPB    = 4.00E-03           TREF   = 25
+ TPHP   = 3.00E-03          FCS    = 0                  )
.ENDL DIO

***************************************************************
*                                                             *
*              1.05V High Vt Junction DIODE MODELS            *
*                                                             *
***************************************************************
*****************************    LIBRARY OF TYPICAL CASE    ******************************
.LIB TT_DIO_hvt
.param
+is_d_hvt= 1         jsw_d_hvt= 1         n_d_hvt= 1         rs_d_hvt= 1
+cj_d_hvt= 1         cjsw_d_hvt= 1
.lib 'models.sp' DIO_hvt
.ENDL TT_DIO_hvt
******************************    LIBRARY OF SLOW CASE    ******************************
.LIB SS_DIO_hvt
.param
+is_d_hvt= 0.7         jsw_d_hvt= 0.5         n_d_hvt= 1.0025         rs_d_hvt= 1.2
+cj_d_hvt= 1.07        cjsw_d_hvt= 1.07
.lib 'models.sp' DIO_hvt
.ENDL SS_DIO_hvt
******************************    LIBRARY OF FAST CASE    ******************************
.LIB FF_DIO_hvt
.param
+is_d_hvt= 1.3         jsw_d_hvt= 2         n_d_hvt= 0.9975         rs_d_hvt= 0.8
+cj_d_hvt= 0.93        cjsw_d_hvt= 0.93
.lib 'models.sp' DIO_hvt
.ENDL FF_DIO_hvt
**************************************************************************
***************************************************************
*                                                             *
*              1.05V High Vt Junction DIODE MODELS             *
*                                                             *
***************************************************************

.LIB DIO_hvt
*
***************************************************************
*                      MODEL OF N+/PW DIODE                   *
*                                                             *
***************************************************************

.MODEL NDIO_hvt D (                                          LEVEL  = 3
+ IS     = '1.9E-07*is_d_hvt' IKR    = 1E10              RS     = '1.0E-10*rs_d_hvt'
+ N      = '1.04*n_d_hvt'     BV     = 10.8              IBV    = 0.03
+ JSW    = '3.5E-13*jsw_d_hvt' CJ     = '9.17E-04*cj_d_hvt' PJ     = 7.56E-4
+ MJ     = 0.25              FC     = 0                  CJSW   = '9.0E-11*cjsw_d_hvt'
+ AREA   = 3.1752E-8         MJSW   = 0.01               TLEVC  = 1
+ CTA    = 1.19E-03          CTP    = 3.57E-04           TRS    = 2.5E-3
+ TCV    = -6.50E-04         TLEV   = 1                  XTI    = 3
+ EG     = 1.17              PHP    = 0.7                PB     = 0.53
+ IK     = 1E20              TPB    = 1.50E-03           TREF   = 25
+ TPHP   = 1.90E-03          FCS    = 0                  )

***************************************************************
*                      MODEL OF P+/NW DIODE                   *
*                                                             *
***************************************************************

.MODEL PDIO_hvt D (                                      LEVEL  = 3
+ IS     = '1.4E-07*is_d_hvt' IKR    = 1E10              RS     = '1.0E-10*rs_d_hvt'
+ N      = '1.04*n_d_hvt'     BV     = 10.5              IBV    = 0.03
+ JSW    = '6.0E-13*jsw_d_hvt' CJ     = '9.57E-04*cj_d_hvt' PJ     = 7.56E-4
+ MJ     = 0.35              FC     = 0                  CJSW   = '7.1E-11*cjsw_d_hvt'
+ AREA   = 3.1752E-8         MJSW   = 0.060              TLEVC  = 1
+ CTA    = 9.38E-04          CTP    = 6.00E-04           TRS    = 2.5E-3
+ TCV    = -7.5E-04          TLEV   = 1                  XTI    = 3
+ EG     = 1.17              PHP    = 0.4                PB     = 0.8
+ IK     = 1E20              TPB    = 1.90E-03           TREF   = 25
+ TPHP   = 1.60E-03          FCS    = 0                  )

.ENDL DIO_hvt

*
***************************************************************
*                                                             *
*                1.8V IO Junction DIODE MODELS                *
*                                                             *
***************************************************************
*****************************    LIBRARY OF TYPICAL CASE    ******************************
.LIB TT_DIO_18
.param
+is_d_18 = 1.0     jsw_d_18 = 1.0      n_d_18    = 1.000
+rs_d_18 = 1.0     cj_d_18  = 1.00     cjsw_d_18 = 1.00
.lib 'models.sp' DIO_18
.ENDL TT_DIO_18
******************************    LIBRARY OF SLOW CASE    ******************************
.LIB SS_DIO_18
.param
+is_d_18 = 0.7     jsw_d_18 = 0.5      n_d_18    = 1.0025
+rs_d_18 = 1.2     cj_d_18  = 1.07     cjsw_d_18 = 1.07
.lib 'models.sp' DIO_18
.ENDL SS_DIO_18
******************************    LIBRARY OF FAST CASE    ******************************
.LIB FF_DIO_18
.param
+is_d_18 = 1.3     jsw_d_18 = 2.0      n_d_18    = 0.9975
+rs_d_18 = 0.8     cj_d_18  = 0.93     cjsw_d_18 = 0.93
.lib 'models.sp' DIO_18
.ENDL FF_DIO_18
*
*
***************************************************************
*                                                             *
*                 1.8V IO Junction DIODE MODELS               *
*                                                             *
***************************************************************
*
.LIB DIO_18

***************************************************************
*                      MODEL OF N+/PW DIODE                   *
*                                                             *
***************************************************************

.MODEL NDIO_18 D (
+ IS   = '1.67E-7*is_d_18'      JSW   = '0.41E-12*jsw_d_18'
+ RS   = '1.29E-10*rs_d_18'     N     = '1.02*n_d_18'
+ CJ   = '8.727E-04*cj_d_18'     CJSW  = '8.14259E-11*cjsw_d_18'
+ BV   = 11.1                   AREA  = 3.1752e-8       PJ    = 7.56E-4
+ MJ   = 0.3                    MJSW  = 0.067           PB    = 0.6
+ PHP  = 0.65                   TRS   = 4E-4            TCV   = -7.5E-04
+ CTA  = 1.14e-3                CTP   = 4E-4            TPB   = 1.00E-03
+ TPHP = 2E-3                   IK    = 1E20            IKR   = 1E10
+ IBV  = 0.03                   TREF  = 25              FC    = 0
+ FCS  = 0                      TLEV  = 1               TLEVC = 1
+ XTI  = 3                      EG    = 1.17            LEVEL = 3   )

***************************************************************
*                      MODEL OF P+/NW DIODE                   *
*                                                             *
***************************************************************

.MODEL PDIO_18 D (
+ IS   = '1.6E-07*is_d_18'      JSW   = '5E-13*jsw_d_18'
+ RS   = '1.0E-10*rs_d_18'      N     = '1.03*n_d_18'
+ CJ   = '9.547E-04*cj_d_18'    CJSW  = '6.6502E-11*cjsw_d_18'
+ BV   = 10.4                    AREA  = 3.1752e-8       PJ    = 7.56E-4
+ MJ   = 0.36                   MJSW  = 0.04            PB    = 0.8
+ PHP  = 0.48                   TRS   = 4E-4            TCV   = -9E-04
+ CTA  = 9.45E-04               CTP   = 2.70E-04        TPB   = 1.9E-03
+ TPHP = 1.00E-03               IK    = 1E20            IKR   = 1E10
+ IBV  = 0.03                   TREF  = 25              FC    = 0
+ FCS  = 0                      TLEV  = 1               TLEVC = 1
+ XTI  = 3                      EG    = 1.17            LEVEL = 3 )

.ENDL DIO_18

*
**************************************************************************
*                                                                        *
*                 1.8V IO NMOS in N-Well varactor MODEL                  *
*                                                                        *
*  Note that the corners are defined such that the capacitance decreases *
*  and increases in SS and FF corners, respectively.  This is to align   *
*  the effects of Tox change to that of the direction of Tox skew in     *
*  MOSFET corners.                                                       *
*                                                                        *
**************************************************************************
***************** CORNER_LIB OF TYPICAL MODEL ****************************
.LIB TT_MOS_CAP_18
.param
+Cgmin_Var18= 1     dCg_Var18= 1     dxL_Var18= 0     dxW_Var18= 0
.lib 'models.sp' MOS_CAP_18
.ENDL TT_MOS_CAP_18
******************* CORNER_LIB OF SLOW MODEL *****************************
.LIB SS_MOS_CAP_18
.param
+Cgmin_Var18= 0.9     dCg_Var18= 0.942     dxL_Var18= 8E-09     dxW_Var18= -1.2E-08
.lib 'models.sp' MOS_CAP_18
.ENDL SS_MOS_CAP_18
******************* CORNER_LIB OF FAST MODEL *****************************
.LIB FF_MOS_CAP_18
.param
+Cgmin_Var18= 1.1     dCg_Var18= 1.058     dxL_Var18= -8E-09     dxW_Var18= 1.2E-08
.lib 'models.sp' MOS_CAP_18
.ENDL FF_MOS_CAP_18
**************************************************************************
*
*
**************************************************************************
*                                                                        *
*                 1.8V IO NMOS in N-Well varactor MODEL                  *
*                                                                        *
**************************************************************************
*
.LIB MOS_CAP_18
*
.subckt nmoscap_18 ng nds lr=1E-6 wr=1E-6 scale=1
.param XL=2E-08
.param XW=2.5E-08
.param area='(lr*scale-XL+dxL_Var18)*(wr*scale-XW+dxW_Var18)'
.param Cgmin='1.24E-10*Cgmin_Var18*(2*(wr*scale-XW+dxW_Var18)+lr*scale-XL+dxL_Var18)+2.8E-10*Cgmin_Var18*(lr*scale-XL+dxL_Var18)+1.29E-03*Cgmin_Var18*area'
.param dCg='2E-12*dCg_Var18*(2*(wr*scale-XW+dxW_Var18)+lr*scale-XL+dxL_Var18)+6.4E-11*dCg_var18*(lr*scale-XL+dxL_Var18)+4.25E-03*dCg_Var18*area'
.param dVgs='-0.1-2.000E-04*(temper-25)'
.param Vgnorm='0.4+1.0E-03*(temper-25)'

cg ng nds 'Cgmin+dCg*(1.0+tanh((v(ng,nds)-dVgs)/Vgnorm))'

.ends nmoscap_18

.ENDL MOS_CAP_18
*
**************************************************************************
*
*   RESISTANCE MODEL
*
**************************************************************************
.LIB TT_RES
.Param
+r_rnodwo        = 96.77           rend_rnodwo     = 11.42u          dxl_rnodwo      = 0.0u            dxw_rnodwo      = 0
+r_rpodwo        = 197.47          rend_rpodwo     = 29.59u          dxl_rpodwo      = 0.0u            dxw_rpodwo      = 0
+r_rnpolywo      = 105.21          rend_rnpolywo   = 15.7u           dxl_rnpolywo    = 0.0u            dxw_rnpolywo    = 0
+r_rppolywo      = 456.43          rend_rppolywo   = 122.5u          dxl_rppolywo    = 0.0u            dxw_rppolywo    = 0
+r_rppolyl       = 11.45           r_rppolys       = 11.45           dxw_rppolys     = 0
+r_rnpolyl       = 11.55           r_rnpolys       = 11.55           dxw_rnpolys     = 0
+r_rnodl         = 11.58           r_rnods         = 11.58           dxw_rnods       = 0
+r_rpodl         = 10.45           r_rpods         = 10.45           dxw_rpods       = 0
+r_rnwod         = 330             r_rnwsti        = 550             r_rm1l          = 0.0699
+r_rm1s          = 0.11            r_rm1w          = 0.1             r_rm2_7l        = 0.0678
+r_rm2_7s        = 0.0953          r_rm2_7w        = 0.0865          r_rm8_9l        = 0.0209
+r_rm8_9s        = 0.022           r_rm8_9w        = 0.0195
.lib 'models.sp' RES
.ENDL TT_RES

.LIB SS_RES
.Param
+r_rnodwo        = '96.77 * 1.15'  rend_rnodwo     = '11.42u * 1.90' dxl_rnodwo      = '0.0u + 0.0u'   dxw_rnodwo      = '0 + 0.040u'
+r_rpodwo        = '197.47 * 1.25' rend_rpodwo     = '29.59u * 1.60' dxl_rpodwo      = '0.0u + 0.0u'   dxw_rpodwo      = '0 + 0.022u'
+r_rnpolywo      = '105.21 * 1.15' rend_rnpolywo   = '15.7u * 1.90'  dxl_rnpolywo    = '0.0u + 0.0u'   dxw_rnpolywo    = '0 + 0.032u'
+r_rppolywo      = '456.43 * 1.15' rend_rppolywo   = '122.5u * 1.60' dxl_rppolywo    = '0.0u + 0.0u'   dxw_rppolywo    = '0 + 0.035u'
+r_rppolyl       = '11.45 * 1.20'  r_rppolys       = '11.45 * 1.21'  dxw_rppolys     = '0 + 0.012u'
+r_rnpolyl       = '11.55 * 1.20'  r_rnpolys       = '11.55 * 1.21'  dxw_rnpolys     = '0 + 0.009u'
+r_rnodl         = '11.58 * 1.15'  r_rnods         = '11.58 * 1.21'  dxw_rnods       = '0 + 0.016u'
+r_rpodl         = '10.45 * 1.15'  r_rpods         = '10.45 * 1.21'  dxw_rpods       = '0 + 0.017u'
+r_rnwod         = '330 * 1.20'    r_rnwsti        = '550 * 1.20'    r_rm1l          = '0.0699 * 1.20'
+r_rm1s          = '0.11 * 1.20'   r_rm1w          = '0.1 * 1.20'    r_rm2_7l        = '0.0678 * 1.20'
+r_rm2_7s        = '0.0953 * 1.20' r_rm2_7w        = '0.0865 * 1.20' r_rm8_9l        = '0.0209 * 1.20'
+r_rm8_9s        = '0.022 * 1.20'  r_rm8_9w        = '0.0195 * 1.20'
.lib 'models.sp' RES
.ENDL SS_RES

.LIB FF_RES
.Param
+r_rnodwo        = '96.77 * 0.85'  rend_rnodwo     = '11.42u * 0.10' dxl_rnodwo      = '0.0u + 0.0u'   dxw_rnodwo      = '0 - 0.040u'
+r_rpodwo        = '197.47 * 0.75' rend_rpodwo     = '29.59u * 0.40' dxl_rpodwo      = '0.0u + 0.0u'   dxw_rpodwo      = '0 - 0.022u'
+r_rnpolywo      = '105.21 * 0.85' rend_rnpolywo   = '15.7u * 0.10'  dxl_rnpolywo    = '0.0u + 0.0u'   dxw_rnpolywo    = '0 - 0.032u'
+r_rppolywo      = '456.43 * 0.85' rend_rppolywo   = '122.5u * 0.40' dxl_rppolywo    = '0.0u + 0.0u'   dxw_rppolywo    = '0 - 0.035u'
+r_rppolyl       = '11.45 * 0.80'  r_rppolys       = '11.45 * 0.79'  dxw_rppolys     = '0 - 0.027u'
+r_rnpolyl       = '11.55 * 0.80'  r_rnpolys       = '11.55 * 0.79'  dxw_rnpolys     = '0 - 0.022u'
+r_rnodl         = '11.58 * 0.85'  r_rnods         = '11.58 * 0.79'  dxw_rnods       = '0 - 0.037u'
+r_rpodl         = '10.45 * 0.85'  r_rpods         = '10.45 * 0.79'  dxw_rpods       = '0 - 0.036u'
+r_rnwod         = '330 * 0.80'    r_rnwsti        = '550 * 0.80'    r_rm1l          = '0.0699 * 0.80'
+r_rm1s          = '0.11 * 0.80'   r_rm1w          = '0.1 * 0.80'    r_rm2_7l        = '0.0678 * 0.80'
+r_rm2_7s        = '0.0953 * 0.80' r_rm2_7w        = '0.0865 * 0.80' r_rm8_9l        = '0.0209 * 0.80'
+r_rm8_9s        = '0.022 * 0.80'  r_rm8_9w        = '0.0195 * 0.80'
.lib 'models.sp' RES
.ENDL FF_RES

.LIB RES

***********************************     N+OD w/o silicide resistor     ***********************************
.subckt rnodwo n1 n2 l=length w=width  scale=1
.param Rsh = r_rnodwo
.param Rend0 = rend_rnodwo
.param dw = '-0.014966091u + dxw_rnodwo'  dl = '0 + dxl_rnodwo'
.param pvcp1 = -6.16E-02   pvcp2 = -1.02E-05   pvcp3 = 2.15E+00   ptcp1 = 1.58E-03   ptcp2 = 7.34E-07
.param pvce1 = -5.65E-02   pvce2 = -5.16E+02   pvce3 = 2.78E-01   ptce1 = 7.57E-04   ptce2 = -1.28E-07
.param tface='1.0+ptce1*(pt-25.0)+ptce2*(pt-25.0)*(pt-25.0)'
.param tfacp='1.0+ptcp1*(pt-25.0)+ptcp2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
Rend1 n1 3 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(n1,3))+pvce3)-tanh(pvce3)))'
Rp 3 4 'Rsh*(l*scale-dl)/(w*scale-dw)*tfacp*(1+pvcp1*(tanh(pvcp2*abs(v(3,4)/(l*scale-dl))+pvcp3)-tanh(pvcp3)))'
Rend2 4 n2 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(4,n2))+pvce3)-tanh(pvce3)))'
.ends rnodwo

***********************************     P+OD w/o silicide resistor     ***********************************
.subckt rpodwo n1 n2 l=length w=width  scale=1
.param Rsh = r_rpodwo
.param Rend0 = rend_rpodwo
.param dw = '-0.013624761u + dxw_rpodwo'  dl = '0 + dxl_rpodwo'
.param pvcp1 = -2.01E-02   pvcp2 = -6.48E-06   pvcp3 = 1.50E+00   ptcp1 = 1.22E-03   ptcp2 = 8.27E-07
.param pvce1 = -6.57E-02   pvce2 = 1.92E+02   pvce3 = 1.77E-01   ptce1 = -4.04E-04   ptce2 = -1.32E-06
.param tface='1.0+ptce1*(pt-25.0)+ptce2*(pt-25.0)*(pt-25.0)'
.param tfacp='1.0+ptcp1*(pt-25.0)+ptcp2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
Rend1 n1 3 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(n1,3))+pvce3)-tanh(pvce3)))'
Rp 3 4 'Rsh*(l*scale-dl)/(w*scale-dw)*tfacp*(1+pvcp1*(tanh(pvcp2*abs(v(3,4)/(l*scale-dl))+pvcp3)-tanh(pvcp3)))'
Rend2 4 n2 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(4,n2))+pvce3)-tanh(pvce3)))'
.ends rpodwo

***********************************     N+POLY w/o silicide resistor     ***********************************
.subckt rnpolywo n1 n2 l=length w=width  scale=1
.param Rsh = r_rnpolywo
.param Rend0 = rend_rnpolywo
.param dw = '0.110291503u + dxw_rnpolywo'  dl = '0 + dxl_rnpolywo'
.param pvcp1 = 7.30E-03   pvcp2 = 5.55E-06   pvcp3 = 4.00E-05   ptcp1 = 2.31E-04   ptcp2 = 3.96E-07
.param pvce1 = -2.25E-02   pvce2 = -2.62E+02   pvce3 = 1.51E+00   ptce1 = -3.84E-05   ptce2 = 8.32E-08
.param tface='1.0+ptce1*(pt-25.0)+ptce2*(pt-25.0)*(pt-25.0)'
.param tfacp='1.0+ptcp1*(pt-25.0)+ptcp2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
Rend1 n1 3 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(n1,3))+pvce3)-tanh(pvce3)))'
Rp 3 4 'Rsh*(l*scale-dl)/(w*scale-dw)*tfacp*(1+pvcp1*(tanh(pvcp2*abs(v(3,4)/(l*scale-dl))+pvcp3)-tanh(pvcp3)))'
Rend2 4 n2 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(4,n2))+pvce3)-tanh(pvce3)))'
.ends rnpolywo

***********************************     P+POLY w/o silicide resistor     ***********************************
.subckt rppolywo n1 n2 l=length w=width  scale=1
.param Rsh = r_rppolywo
.param Rend0 = rend_rppolywo
.param dw = '0.0864u + dxw_rppolywo'  dl = '0 + dxl_rppolywo'
.param pvcp1 = 1.28E-01   pvcp2 = -5.22E-06   pvcp3 = 3.03E+00   ptcp1 = -1.57E-04   ptcp2 = 7.05E-07
.param pvce1 = -9.42E-02   pvce2 = 8.24E+00   pvce3 = -8.47E-01   ptce1 = -1.33E-03   ptce2 = 6.57E-07
.param tface='1.0+ptce1*(pt-25.0)+ptce2*(pt-25.0)*(pt-25.0)'
.param tfacp='1.0+ptcp1*(pt-25.0)+ptcp2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
Rend1 n1 3 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(n1,3))+pvce3)-tanh(pvce3)))'
Rp 3 4 'Rsh*(l*scale-dl)/(w*scale-dw)*tfacp*(1+pvcp1*(tanh(pvcp2*abs(v(3,4)/(l*scale-dl))+pvcp3)-tanh(pvcp3)))'
Rend2 4 n2 'Rend0/w/scale*tface*(1+pvce1*(tanh(pvce2*abs(v(4,n2))+pvce3)-tanh(pvce3)))'
.ends rppolywo

***********************************     P+POLY silicide resistor (W>=1.8um)     ***********************************
.subckt rppolyl n1 n2 l=length w=width scale=1
.param Rsh = r_rppolyl
.param dw = 0.005u
.param pvc1 = 3.57E-07   pvc2 = 4.46E-11   ptc1 = 2.75E-03   ptc2 = 1.48E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rppolyl

***********************************     P+POLY silicide resistor (W<1.8um)     ***********************************
.subckt rppolys n1 n2 l=length w=width scale=1
.param Rsh = r_rppolys
.param dw = '0.005u + dxw_rppolys'
.param pvc1 = 3.06E-09   pvc2 = 7.64E-12   ptc1 = 3.13E-03   ptc2 = 2.71E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rppolys

***********************************     N+POLY silicide resistor (W>=1.8um)     ***********************************
.subckt rnpolyl n1 n2 l=length w=width scale=1
.param Rsh = r_rnpolyl
.param dw = 0.024u
.param pvc1 = 3.51E-07   pvc2 = 4.39E-11   ptc1 = 2.59E-03   ptc2 = -1.68E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rnpolyl

***********************************     N+POLY silicide resistor (W<1.8um)     ***********************************
.subckt rnpolys n1 n2 l=length w=width scale=1
.param Rsh = r_rnpolys
.param dw = '0.024u + dxw_rnpolys'
.param pvc1 = 5.83E-08   pvc2 = 5.83E-12   ptc1 = 3.06E-03   ptc2 = 1.61E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rnpolys

***********************************     N+OD silicide resistor (W>=1.8um)     ***********************************
.subckt rnodl n1 n2 l=length w=width scale=1
.param Rsh = r_rnodl
.param dw = -0.015u
.param pvc1 = 2.72E-08   pvc2 = 8.16E-12   ptc1 = 3.23E-03   ptc2 = 1.26E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rnodl

***********************************     N+OD silicide resistor (W<1.8um)     ***********************************
.subckt rnods n1 n2 l=length w=width scale=1
.param Rsh = r_rnods
.param dw = '-0.015u + dxw_rnods'
.param pvc1 = 2.78E-09   pvc2 = 6.94E-12   ptc1 = 2.93E-03   ptc2 = 1.32E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rnods

***********************************     P+OD silicide resistor (W>=1.8um)     ***********************************
.subckt rpodl n1 n2 l=length w=width scale=1
.param Rsh = r_rpodl
.param dw = -0.024u
.param pvc1 = 1.01E-08   pvc2 = 9.05E-12   ptc1 = 3.33E-03   ptc2 = 2.43E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rpodl

***********************************     P+OD silicide resistor (W<1.8um)     ***********************************
.subckt rpods n1 n2 l=length w=width scale=1
.param Rsh = r_rpods
.param dw = '-0.024u + dxw_rpods'
.param pvc1 = -6.58E-08   pvc2 = 5.27E-12   ptc1 = 2.90E-03   ptc2 = 1.77E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rpods

***********************************     N-Well under OD resistor     ***********************************
.subckt rnwod n1 n2 l=length w=width scale=1
.param rsh = r_rnwod
.param dw = 0.29u
.param pvc1 = 0.0124   pvc2 = -0.000298   ptc1 = 2.83E-03   ptc2 = 1.04E-05
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*abs(v(n2,n1))+pvc2*v(n2,n1)*v(n2,n1))*tfac'
.ends rnwod

***********************************     N-well under STI resistor     ***********************************
.subckt rnwsti n1 n2 l=length w=width scale=1
.param rsh = r_rnwsti
.param dw = 0.41u
.param pvc1 = 0.0116   pvc2 = -0.000457   ptc1 = 1.73E-03   ptc2 = 9.66E-06
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*abs(v(n2,n1))+pvc2*v(n2,n1)*v(n2,n1))*tfac'
.ends rnwsti

***********************************     Metal 1 with W/S=0.108/0.324     ***********************************
.subckt rm1l n1 n2 l=length w=width scale=1
.param Rsh = r_rm1l
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.24E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm1l

***********************************     Metal 1 with W/S=0.108/0.108     ***********************************
.subckt rm1s n1 n2 l=length w=width scale=1
.param Rsh = r_rm1s
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.24E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm1s

***********************************     Metal 1 with W/S=0.324/0.162     ***********************************
.subckt rm1w n1 n2 l=length w=width scale=1
.param Rsh = r_rm1w
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.24E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm1w

***********************************     Metal 2 to 7 with W/S=0.126/0.378     ***********************************
.subckt rm2_7l n1 n2 l=length w=width scale=1
.param Rsh = r_rm2_7l
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.29E-03   ptc2 = -1.32E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm2_7l

***********************************     Metal 2 to 7 with W/S=0.126/0.126     ***********************************
.subckt rm2_7s n1 n2 l=length w=width scale=1
.param Rsh = r_rm2_7s
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.29E-03   ptc2 = -1.32E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm2_7s

***********************************     Metal 2 to 7 with W/S=0.378/0.189     ***********************************
.subckt rm2_7w n1 n2 l=length w=width scale=1
.param Rsh = r_rm2_7w
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.29E-03   ptc2 = -1.32E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm2_7w

***********************************     Metal 8 to 9 with W/S=0.378/0.567     ***********************************
.subckt rm8_9l n1 n2 l=length w=width scale=1
.param Rsh = r_rm8_9l
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.37E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm8_9l

***********************************     Metal 8 to 9 with W/S=0.378/0.378     ***********************************
.subckt rm8_9s n1 n2 l=length w=width scale=1
.param Rsh = r_rm8_9s
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.37E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm8_9s

***********************************     Metal 8 to 9 with W/S=0.378/1.134     ***********************************
.subckt rm8_9w n1 n2 l=length w=width scale=1
.param Rsh = r_rm8_9w
.param dw = 0
.param pvc1 = 0   pvc2 = 0   ptc1 = 3.37E-03   ptc2 = 3.37E-07
.param tfac='1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0)'
.param pt='temper'
r1 n1 n2 'rsh*l*scale/(w*scale-dw)*(1+pvc1*(abs(v(n2,n1))/l/scale)+pvc2*(v(n2,n1)/l/scale)*(v(n2,n1)/l/scale))*tfac'
.ends rm8_9w

.ENDL RES
